* SPICE netlist generated by Yosys 0.55+115 (git sha1 8f6d7a304, clang++ 18.1.8 -fPIC -O3)

.SUBCKT _paramod_capdriver_Ndac_s32'00000000000000000000000000010000 dac_state.0 dac_state.1 dac_state.2 dac_state.3 dac_state.4 dac_state.5 dac_state.6 dac_state.7 dac_state.8 dac_state.9 dac_state.10 dac_state.11 dac_state.12 dac_state.13 dac_state.14 dac_state.15 dac_drive_invert dac_drive.0 dac_drive.1 dac_drive.2 dac_drive.3 dac_drive.4 dac_drive.5 dac_drive.6 dac_drive.7 dac_drive.8 dac_drive.9 dac_drive.10 dac_drive.11 dac_drive.12 dac_drive.13 dac_drive.14 dac_drive.15
X0 dac_state.0 dac_drive_invert dac_drive.0 CKXOR2D0LVT
X1 dac_drive_invert dac_state.1 dac_drive.1 CKXOR2D0LVT
X2 dac_drive_invert dac_state.2 dac_drive.2 CKXOR2D0LVT
X3 dac_drive_invert dac_state.3 dac_drive.3 CKXOR2D0LVT
X4 dac_drive_invert dac_state.4 dac_drive.4 CKXOR2D0LVT
X5 dac_drive_invert dac_state.5 dac_drive.5 CKXOR2D0LVT
X6 dac_drive_invert dac_state.6 dac_drive.6 CKXOR2D0LVT
X7 dac_drive_invert dac_state.7 dac_drive.7 CKXOR2D0LVT
X8 dac_drive_invert dac_state.8 dac_drive.8 CKXOR2D0LVT
X9 dac_drive_invert dac_state.9 dac_drive.9 CKXOR2D0LVT
X10 dac_drive_invert dac_state.10 dac_drive.10 CKXOR2D0LVT
X11 dac_drive_invert dac_state.11 dac_drive.11 CKXOR2D0LVT
X12 dac_drive_invert dac_state.12 dac_drive.12 CKXOR2D0LVT
X13 dac_drive_invert dac_state.13 dac_drive.13 CKXOR2D0LVT
X14 dac_drive_invert dac_state.14 dac_drive.14 CKXOR2D0LVT
X15 dac_drive_invert dac_state.15 dac_drive.15 CKXOR2D0LVT
.ENDS _paramod_capdriver_Ndac_s32'00000000000000000000000000010000

.SUBCKT _paramod_salogic_Ndac_s32'00000000000000000000000000010000 clk_init clk_update dac_astate.0 dac_astate.1 dac_astate.2 dac_astate.3 dac_astate.4 dac_astate.5 dac_astate.6 dac_astate.7 dac_astate.8 dac_astate.9 dac_astate.10 dac_astate.11 dac_astate.12 dac_astate.13 dac_astate.14 dac_astate.15 dac_bstate.0 dac_bstate.1 dac_bstate.2 dac_bstate.3 dac_bstate.4 dac_bstate.5 dac_bstate.6 dac_bstate.7 dac_bstate.8 dac_bstate.9 dac_bstate.10 dac_bstate.11 dac_bstate.12 dac_bstate.13 dac_bstate.14 dac_bstate.15 dac_mode comp dac_state.0 dac_state.1 dac_state.2 dac_state.3 dac_state.4 dac_state.5 dac_state.6 dac_state.7 dac_state.8 dac_state.9 dac_state.10 dac_state.11 dac_state.12 dac_state.13 dac_state.14 dac_state.15
X0 clk_init 1 CKND0LVT
X1 clk_init dac_mode 2 NR2D0LVT
X2 dac_bstate.0 dac_mode 3 INR2D0LVT
X3 dac_bstate.1 dac_mode 4 INR2D0LVT
X4 dac_bstate.2 dac_mode 5 INR2D0LVT
X5 dac_bstate.3 dac_mode 6 INR2D0LVT
X6 dac_bstate.4 dac_mode 7 INR2D0LVT
X7 dac_bstate.5 dac_mode 8 INR2D0LVT
X8 dac_bstate.6 dac_mode 9 INR2D0LVT
X9 dac_bstate.7 dac_mode 10 INR2D0LVT
X10 dac_bstate.8 dac_mode 11 INR2D0LVT
X11 dac_bstate.9 dac_mode 12 INR2D0LVT
X12 dac_bstate.10 dac_mode 13 INR2D0LVT
X13 dac_bstate.11 dac_mode 14 INR2D0LVT
X14 dac_bstate.12 dac_mode 15 INR2D0LVT
X15 dac_bstate.13 dac_mode 16 INR2D0LVT
X16 dac_bstate.14 dac_mode 17 INR2D0LVT
X17 dac_bstate.15 comp dac_mode 18 MUX2D0LVT
X18 clk_init dac_astate.0 dac_state.0 DFQD1LVT
X19 clk_init dac_astate.1 dac_state.1 DFQD1LVT
X20 clk_init dac_astate.2 dac_state.2 DFQD1LVT
X21 clk_init dac_astate.3 dac_state.3 DFQD1LVT
X22 clk_init dac_astate.4 dac_state.4 DFQD1LVT
X23 clk_init dac_astate.5 dac_state.5 DFQD1LVT
X24 clk_init dac_astate.6 dac_state.6 DFQD1LVT
X25 clk_init dac_astate.7 dac_state.7 DFQD1LVT
X26 clk_init dac_astate.8 dac_state.8 DFQD1LVT
X27 clk_init dac_astate.9 dac_state.9 DFQD1LVT
X28 clk_init dac_astate.10 dac_state.10 DFQD1LVT
X29 clk_init dac_astate.11 dac_state.11 DFQD1LVT
X30 clk_init dac_astate.12 dac_state.12 DFQD1LVT
X31 clk_init dac_astate.13 dac_state.13 DFQD1LVT
X32 clk_init dac_astate.14 dac_state.14 DFQD1LVT
X33 clk_init dac_astate.15 dac_state.15 DFQD1LVT
X34 clk_update 18 1 dac_state.15 EDFQD1LVT
X35 clk_update 3 2 dac_state.0 EDFQD1LVT
X36 clk_update 17 2 dac_state.14 EDFQD1LVT
X37 clk_update 16 2 dac_state.13 EDFQD1LVT
X38 clk_update 15 2 dac_state.12 EDFQD1LVT
X39 clk_update 14 2 dac_state.11 EDFQD1LVT
X40 clk_update 13 2 dac_state.10 EDFQD1LVT
X41 clk_update 12 2 dac_state.9 EDFQD1LVT
X42 clk_update 11 2 dac_state.8 EDFQD1LVT
X43 clk_update 10 2 dac_state.7 EDFQD1LVT
X44 clk_update 9 2 dac_state.6 EDFQD1LVT
X45 clk_update 8 2 dac_state.5 EDFQD1LVT
X46 clk_update 7 2 dac_state.4 EDFQD1LVT
X47 clk_update 6 2 dac_state.3 EDFQD1LVT
X48 clk_update 5 2 dac_state.2 EDFQD1LVT
X49 clk_update 4 2 dac_state.1 EDFQD1LVT
V0 VSS dac_cycle.0 DC 0
V1 VSS dac_cycle.1 DC 0
V2 VSS dac_cycle.2 DC 0
V3 VSS dac_cycle.3 DC 0
V4 VSS dac_cycle.4 DC 0
V5 VSS dac_cycle.5 DC 0
V6 VSS dac_cycle.6 DC 0
V7 VSS dac_cycle.7 DC 0
V8 VSS dac_cycle.8 DC 0
V9 VSS dac_cycle.9 DC 0
V10 VSS dac_cycle.10 DC 0
V11 VSS dac_cycle.11 DC 0
V12 VSS dac_cycle.12 DC 0
V13 VSS dac_cycle.13 DC 0
V14 VSS dac_cycle.14 DC 0
V15 VDD dac_cycle.15 DC 0
.ENDS _paramod_salogic_Ndac_s32'00000000000000000000000000010000

.SUBCKT clkgate seq_init seq_samp seq_comp seq_update en_init en_samp_p en_samp_n en_comp en_update_p en_update_n clk_init clk_samp_p clk_samp_n clk_comp clk_update_p clk_update_n
X0 seq_init en_init clk_init AN2D0LVT
X1 seq_samp en_samp_p clk_samp_p AN2D0LVT
X2 seq_samp en_samp_n clk_samp_n AN2D0LVT
X3 seq_comp en_comp clk_comp AN2D0LVT
X4 seq_update en_update_p clk_update_p AN2D0LVT
X5 seq_update en_update_n clk_update_n AN2D0LVT
.ENDS clkgate

X0 vdac_n dac_cap_botplate_n.0 dac_cap_botplate_n.1 dac_cap_botplate_n.2 dac_cap_botplate_n.3 dac_cap_botplate_n.4 dac_cap_botplate_n.5 dac_cap_botplate_n.6 dac_cap_botplate_n.7 dac_cap_botplate_n.8 dac_cap_botplate_n.9 dac_cap_botplate_n.10 dac_cap_botplate_n.11 dac_cap_botplate_n.12 dac_cap_botplate_n.13 dac_cap_botplate_n.14 dac_cap_botplate_n.15 caparray
X1 vdac_p dac_cap_botplate_p.0 dac_cap_botplate_p.1 dac_cap_botplate_p.2 dac_cap_botplate_p.3 dac_cap_botplate_p.4 dac_cap_botplate_p.5 dac_cap_botplate_p.6 dac_cap_botplate_p.7 dac_cap_botplate_p.8 dac_cap_botplate_p.9 dac_cap_botplate_p.10 dac_cap_botplate_p.11 dac_cap_botplate_p.12 dac_cap_botplate_p.13 dac_cap_botplate_p.14 dac_cap_botplate_p.15 caparray
X2 dac_state_n.0 dac_state_n.1 dac_state_n.2 dac_state_n.3 dac_state_n.4 dac_state_n.5 dac_state_n.6 dac_state_n.7 dac_state_n.8 dac_state_n.9 dac_state_n.10 dac_state_n.11 dac_state_n.12 dac_state_n.13 dac_state_n.14 dac_state_n.15 VSS dac_cap_botplate_n.0 dac_cap_botplate_n.1 dac_cap_botplate_n.2 dac_cap_botplate_n.3 dac_cap_botplate_n.4 dac_cap_botplate_n.5 dac_cap_botplate_n.6 dac_cap_botplate_n.7 dac_cap_botplate_n.8 dac_cap_botplate_n.9 dac_cap_botplate_n.10 dac_cap_botplate_n.11 dac_cap_botplate_n.12 dac_cap_botplate_n.13 dac_cap_botplate_n.14 dac_cap_botplate_n.15 _paramod_capdriver_Ndac_s32'00000000000000000000000000010000
X3 dac_state_p.0 dac_state_p.1 dac_state_p.2 dac_state_p.3 dac_state_p.4 dac_state_p.5 dac_state_p.6 dac_state_p.7 dac_state_p.8 dac_state_p.9 dac_state_p.10 dac_state_p.11 dac_state_p.12 dac_state_p.13 dac_state_p.14 dac_state_p.15 VSS dac_cap_botplate_p.0 dac_cap_botplate_p.1 dac_cap_botplate_p.2 dac_cap_botplate_p.3 dac_cap_botplate_p.4 dac_cap_botplate_p.5 dac_cap_botplate_p.6 dac_cap_botplate_p.7 dac_cap_botplate_p.8 dac_cap_botplate_p.9 dac_cap_botplate_p.10 dac_cap_botplate_p.11 dac_cap_botplate_p.12 dac_cap_botplate_p.13 dac_cap_botplate_p.14 dac_cap_botplate_p.15 _paramod_capdriver_Ndac_s32'00000000000000000000000000010000
X4 seq_init seq_samp seq_comp seq_update en_init en_samp_p en_samp_n en_comp en_update_p en_update_n clk_init clk_samp_p clk_samp_n clk_comp clk_update_p clk_update_n clkgate
X5 vdac_p vdac_n comp_out_p comp_out_n clk_comp comp
X6 clk_init clk_update_n dac_astate_n.0 dac_astate_n.1 dac_astate_n.2 dac_astate_n.3 dac_astate_n.4 dac_astate_n.5 dac_astate_n.6 dac_astate_n.7 dac_astate_n.8 dac_astate_n.9 dac_astate_n.10 dac_astate_n.11 dac_astate_n.12 dac_astate_n.13 dac_astate_n.14 dac_astate_n.15 dac_bstate_n.0 dac_bstate_n.1 dac_bstate_n.2 dac_bstate_n.3 dac_bstate_n.4 dac_bstate_n.5 dac_bstate_n.6 dac_bstate_n.7 dac_bstate_n.8 dac_bstate_n.9 dac_bstate_n.10 dac_bstate_n.11 dac_bstate_n.12 dac_bstate_n.13 dac_bstate_n.14 dac_bstate_n.15 dac_mode_n comp_out_p dac_state_n.0 dac_state_n.1 dac_state_n.2 dac_state_n.3 dac_state_n.4 dac_state_n.5 dac_state_n.6 dac_state_n.7 dac_state_n.8 dac_state_n.9 dac_state_n.10 dac_state_n.11 dac_state_n.12 dac_state_n.13 dac_state_n.14 dac_state_n.15 _paramod_salogic_Ndac_s32'00000000000000000000000000010000
X7 clk_init clk_update_p dac_astate_p.0 dac_astate_p.1 dac_astate_p.2 dac_astate_p.3 dac_astate_p.4 dac_astate_p.5 dac_astate_p.6 dac_astate_p.7 dac_astate_p.8 dac_astate_p.9 dac_astate_p.10 dac_astate_p.11 dac_astate_p.12 dac_astate_p.13 dac_astate_p.14 dac_astate_p.15 dac_bstate_p.0 dac_bstate_p.1 dac_bstate_p.2 dac_bstate_p.3 dac_bstate_p.4 dac_bstate_p.5 dac_bstate_p.6 dac_bstate_p.7 dac_bstate_p.8 dac_bstate_p.9 dac_bstate_p.10 dac_bstate_p.11 dac_bstate_p.12 dac_bstate_p.13 dac_bstate_p.14 dac_bstate_p.15 dac_mode_p comp_out_n dac_state_p.0 dac_state_p.1 dac_state_p.2 dac_state_p.3 dac_state_p.4 dac_state_p.5 dac_state_p.6 dac_state_p.7 dac_state_p.8 dac_state_p.9 dac_state_p.10 dac_state_p.11 dac_state_p.12 dac_state_p.13 dac_state_p.14 dac_state_p.15 _paramod_salogic_Ndac_s32'00000000000000000000000000010000
X8 vin_n vdac_n clk_samp_n sampswitch
X9 vin_p vdac_p clk_samp_p sampswitch
V0 comp_out_p comp_out DC 0

************************
* end of SPICE netlist *
************************
