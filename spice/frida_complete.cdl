* Complete FRIDA ADC netlist - concatenated from all subcircuits
* Generated by concat_netlists.py

.INCLUDE /eda/kits/TSMC/65LP/2024/digital/Back_End/spice/tcbn65lplvt_200a/tcbn65lplvt_200a.spi
.INCLUDE /eda/kits/TSMC/65LP/2024/digital/Back_End/spice/tcbn65lp_200a/tcbn65lp_200a.spi

* ========== sampswitch.cdl ==========
* Sampling switch implementation with PMOS/NMOS pair
* Drains and sources connected, gates driven by opposite polarity

.SUBCKT sampswitch vin vout clk clk_b vdd_a vss_a
*.PININFO vin:I vout:O clk:I clk_b:I vdd_a:B vss_a:B

Mp1 vout clk_b vin vdd_a pch_lvt l=60n w=5u m=1
Mn1 vout clk vin vss_a nch_lvt l=60n w=4u m=1

.ENDS sampswitch

* ========== comp.cdl ==========
************************************************************************
* Library Name:  frida
* Top Cell Name: comp
* View Name:     schematic
************************************************************************

*.BUSDELIMITER [

************************************************************************
* Library Name: frida
* Cell Name:    comp_inverter_lvil
* View Name:    schematic
************************************************************************

.SUBCKT comp_inverter_lvil GND IN OUT VDD
*.PININFO IN:I OUT:O GND:B VDD:B
MMN OUT IN GND GND nch_lvt l=60n w=390.0n m=1
MMP OUT IN VDD VDD pch_hvt l=60n w=520.0n m=1
.ENDS comp_inverter_lvil

************************************************************************
* Library Name: frida
* Cell Name:    comp_sr
* View Name:    schematic
************************************************************************

.SUBCKT comp_sr COMP_N COMP_P GND LATCH_N LATCH_P VDD
*.PININFO COMP_N:I COMP_P:I LATCH_N:O LATCH_P:O GND:B VDD:B

* cross coupler nor gates
XI30 net41 net38 net35 VDD GND / NR2D2
XI31 net35 net42 net38 VDD GND / NR2D2

* 1st stage buffers
XI45 net35 net39 VDD GND / CKND4
XI48 net38 net40 VDD GND / CKND4

* 2nd stage buffers
XI46 net39 LATCH_P VDD GND / CKND8
XI47 net40 LATCH_N VDD GND / CKND8

XI22 GND COMP_P net41 VDD / comp_inverter_lvil
XI0 GND COMP_N net42 VDD / comp_inverter_lvil
XI1[5] VDD GND / DCAP8
XI1[4] VDD GND / DCAP8
XI1[3] VDD GND / DCAP8
XI1[2] VDD GND / DCAP8
XI1[1] VDD GND / DCAP8
XI1[0] VDD GND / DCAP8
.ENDS comp_sr

************************************************************************
* Library Name: frida
* Cell Name:    comp_latch
* View Name:    schematic
************************************************************************

.SUBCKT comp_latch CLK GND INN INP OUTN OUTP VDD
*.PININFO CLK:I INN:I INP:I OUTN:O OUTP:O GND:B VDD:B
MM0 tail CLK GND GND nch_lvt l=800n w=550.0n m=1
MM2 net037 INN tail GND nch_lvt l=300n w=1.1u m=4
MM8[3] tail GND GND GND nch_lvt l=60n w=1.1u m=1
MM8[2] tail GND GND GND nch_lvt l=60n w=1.1u m=1
MM8[1] tail GND GND GND nch_lvt l=60n w=1.1u m=1
MM8[0] tail GND GND GND nch_lvt l=60n w=1.1u m=1
MM1 net031 INP tail GND nch_lvt l=300n w=1.1u m=4
MM3 OUTN OUTP net031 GND nch_lvt l=350.0n w=750.0n m=4
MM4 OUTP OUTN net037 GND nch_lvt l=350.0n w=750.0n m=4
MS2 net037 CLK VDD VDD pch_lvt l=60n w=500n m=2
MS4 OUTP CLK VDD VDD pch_lvt l=60n w=500n m=2
MS1 net031 CLK VDD VDD pch_lvt l=60n w=500n m=2
MM7 tail CLK VDD VDD pch_lvt l=60n w=500n m=1
MM6 OUTP OUTN VDD VDD pch_lvt l=1u w=2u m=2
MM5 OUTN OUTP VDD VDD pch_lvt l=1u w=2u m=2
MS3 OUTN CLK VDD VDD pch_lvt l=60n w=500n m=2
.ENDS comp_latch

************************************************************************
* Library Name: frida
* Cell Name:    comp
* View Name:    schematic
************************************************************************

.SUBCKT comp vin_p vin_n dout_p dout_n clk vdd_a vss_a
*.PININFO vin_p:I vin_n:I dout_p:O dout_n:O clk:I vdd_a:B vss_a:B
XI3 COMP_N COMP_P vss_a dout_n dout_p vdd_a / comp_sr
XLATCH clk vss_a vin_n vin_p COMP_N COMP_P vdd_a / comp_latch
.ENDS comp

* ========== capdriver.cdl ==========
* Function explanation:
* - XOR gates implement: dac_drive[i] = dac_state[i] XOR dac_drive_invert
* - When dac_drive_invert = 0: dac_drive[i] = dac_state[i] (buffer mode)
* - When dac_drive_invert = 1: dac_drive[i] = ~dac_state[i] (invert mode)
*
* Control signal behavior (dac_drive_invert is active high):
* - dac_drive_invert = 0: Output direct DAC state (normal operation)
* - dac_drive_invert = 1: Output inverted DAC state (differential mode)
*
* Driver sizing rationale:
* - Bits 15-14 (MSBs): 2x CKXOR2D4LVT = ~8x drive strength (largest capacitors)
* - Bits 13-12: 1x CKXOR2D4LVT = ~4x drive strength (large capacitors)
* - Bits 11-0: 1x CKXOR2D2LVT = ~2x drive strength (smaller capacitors)
*
* This provides binary-weighted drive strength that matches the binary-weighted
* capacitor array structure typical in SAR ADC designs.

*.BUSDELIMITER [

.SUBCKT capdriver dac_state[15] dac_state[14] dac_state[13] dac_state[12] dac_state[11] dac_state[10] dac_state[9] dac_state[8] dac_state[7] dac_state[6] dac_state[5] dac_state[4] dac_state[3] dac_state[2] dac_state[1] dac_state[0] dac_drive_invert dac_drive[15] dac_drive[14] dac_drive[13] dac_drive[12] dac_drive[11] dac_drive[10] dac_drive[9] dac_drive[8] dac_drive[7] dac_drive[6] dac_drive[5] dac_drive[4] dac_drive[3] dac_drive[2] dac_drive[1] dac_drive[0] vdd_dac vss_dac
*.PININFO dac_state[15]:I dac_state[14]:I dac_state[13]:I dac_state[12]:I dac_state[11]:I dac_state[10]:I dac_state[9]:I dac_state[8]:I dac_state[7]:I dac_state[6]:I dac_state[5]:I dac_state[4]:I dac_state[3]:I dac_state[2]:I dac_state[1]:I dac_state[0]:I dac_drive_invert:I dac_drive[15]:O dac_drive[14]:O dac_drive[13]:O dac_drive[12]:O dac_drive[11]:O dac_drive[10]:O dac_drive[9]:O dac_drive[8]:O dac_drive[7]:O dac_drive[6]:O dac_drive[5]:O dac_drive[4]:O dac_drive[3]:O dac_drive[2]:O dac_drive[1]:O dac_drive[0]:O vdd_dac:B vss_dac:B

Xxor15_0 dac_drive_invert dac_state[15] dac_drive[15] vdd_dac vss_dac / CKXOR2D4LVT
Xxor15_1 dac_drive_invert dac_state[15] dac_drive[15] vdd_dac vss_dac / CKXOR2D4LVT
Xxor14_0 dac_drive_invert dac_state[14] dac_drive[14] vdd_dac vss_dac / CKXOR2D4LVT
Xxor14_1 dac_drive_invert dac_state[14] dac_drive[14] vdd_dac vss_dac / CKXOR2D4LVT
Xxor13 dac_drive_invert dac_state[13] dac_drive[13] vdd_dac vss_dac / CKXOR2D4LVT
Xxor12 dac_drive_invert dac_state[12] dac_drive[12] vdd_dac vss_dac / CKXOR2D4LVT
Xxor11 dac_drive_invert dac_state[11] dac_drive[11] vdd_dac vss_dac / CKXOR2D2LVT
Xxor10 dac_drive_invert dac_state[10] dac_drive[10] vdd_dac vss_dac / CKXOR2D2LVT
Xxor9 dac_drive_invert dac_state[9] dac_drive[9] vdd_dac vss_dac / CKXOR2D2LVT
Xxor8 dac_drive_invert dac_state[8] dac_drive[8] vdd_dac vss_dac / CKXOR2D2LVT
Xxor7 dac_drive_invert dac_state[7] dac_drive[7] vdd_dac vss_dac / CKXOR2D2LVT
Xxor6 dac_drive_invert dac_state[6] dac_drive[6] vdd_dac vss_dac / CKXOR2D2LVT
Xxor5 dac_drive_invert dac_state[5] dac_drive[5] vdd_dac vss_dac / CKXOR2D2LVT
Xxor4 dac_drive_invert dac_state[4] dac_drive[4] vdd_dac vss_dac / CKXOR2D2LVT
Xxor3 dac_drive_invert dac_state[3] dac_drive[3] vdd_dac vss_dac / CKXOR2D2LVT
Xxor2 dac_drive_invert dac_state[2] dac_drive[2] vdd_dac vss_dac / CKXOR2D2LVT
Xxor1 dac_drive_invert dac_state[1] dac_drive[1] vdd_dac vss_dac / CKXOR2D2LVT
Xxor0 dac_drive_invert dac_state[0] dac_drive[0] vdd_dac vss_dac / CKXOR2D2LVT

.ENDS capdriver

* ========== caparray.cdl ==========
*.BUSDELIMITER [

.SUBCKT caparray cap_topplate cap_shieldplate cap_botplate_main[15] cap_botplate_main[14] cap_botplate_main[13] cap_botplate_main[12] cap_botplate_main[11] cap_botplate_main[10] cap_botplate_main[9] cap_botplate_main[8] cap_botplate_main[7] cap_botplate_main[6] cap_botplate_main[5] cap_botplate_main[4] cap_botplate_main[3] cap_botplate_main[2] cap_botplate_main[1] cap_botplate_main[0] cap_botplate_diff[15] cap_botplate_diff[14] cap_botplate_diff[13] cap_botplate_diff[12] cap_botplate_diff[11] cap_botplate_diff[10] cap_botplate_diff[9] cap_botplate_diff[8] cap_botplate_diff[7] cap_botplate_diff[6] cap_botplate_diff[5] cap_botplate_diff[4] cap_botplate_diff[3] cap_botplate_diff[2] cap_botplate_diff[1] cap_botplate_diff[0]
*.PININFO cap_topplate:B cap_shieldplate:B cap_botplate_main[15]:B cap_botplate_main[14]:B cap_botplate_main[13]:B cap_botplate_main[12]:B cap_botplate_main[11]:B cap_botplate_main[10]:B cap_botplate_main[9]:B cap_botplate_main[8]:B cap_botplate_main[7]:B cap_botplate_main[6]:B cap_botplate_main[5]:B cap_botplate_main[4]:B cap_botplate_main[3]:B cap_botplate_main[2]:B cap_botplate_main[1]:B cap_botplate_main[0]:B cap_botplate_diff[15]:B cap_botplate_diff[14]:B cap_botplate_diff[13]:B cap_botplate_diff[12]:B cap_botplate_diff[11]:B cap_botplate_diff[10]:B cap_botplate_diff[9]:B cap_botplate_diff[8]:B cap_botplate_diff[7]:B cap_botplate_diff[6]:B cap_botplate_diff[5]:B cap_botplate_diff[4]:B cap_botplate_diff[3]:B cap_botplate_diff[2]:B cap_botplate_diff[1]:B cap_botplate_diff[0]:B

* Weighted capacitor array implementation
* Weights: [768, 512, 320, 192, 96, 64, 32, 24, 12, 10, 5, 4, 4, 2, 1, 1] fF

* Main and Diff capacitors based on exact weight calculations
* Weight 768: 768/64 = 12, so 12*0.4*(65+64) = 619.2f main, 12*0.4*(65-64) = 4.8f diff
Cmain15 cap_topplate cap_botplate_main[15] capacitor c=619.2f
Cdiff15 cap_topplate cap_botplate_diff[15] capacitor c=4.8f

* Weight 512: 512/64 = 8, so 8*0.4*(65+64) = 412.8f main, 8*0.4*(65-64) = 3.2f diff
Cmain14 cap_topplate cap_botplate_main[14] capacitor c=412.8f
Cdiff14 cap_topplate cap_botplate_diff[14] capacitor c=3.2f

* Weight 320: 320/64 = 5, so 5*0.4*(65+64) = 258f main, 5*0.4*(65-64) = 2f diff
Cmain13 cap_topplate cap_botplate_main[13] capacitor c=258f
Cdiff13 cap_topplate cap_botplate_diff[13] capacitor c=2f

* Weight 192: 192/64 = 3, so 3*0.4*(65+64) = 154.8f main, 3*0.4*(65-64) = 1.2f diff
Cmain12 cap_topplate cap_botplate_main[12] capacitor c=154.8f
Cdiff12 cap_topplate cap_botplate_diff[12] capacitor c=1.2f

* Weight 96: 64+32, so 0.4*(65+64)+0.4*(65+32) = 90.4f main, 0.4*(65-64)+0.4*(65-32) = 13.6f diff
Cmain11 cap_topplate cap_botplate_main[11] capacitor c=90.4f
Cdiff11 cap_topplate cap_botplate_diff[11] capacitor c=13.6f

* Weight 64: Single 64 section, 0.4*(65+64) = 51.6f main, 0.4*(65-64) = 0.4f diff
Cmain10 cap_topplate cap_botplate_main[10] capacitor c=51.6f
Cdiff10 cap_topplate cap_botplate_diff[10] capacitor c=0.4f

* Weight 32: 0.4*(65+32) = 38.8f main, 0.4*(65-32) = 13.2f diff
Cmain9 cap_topplate cap_botplate_main[9] capacitor c=38.8f
Cdiff9 cap_topplate cap_botplate_diff[9] capacitor c=13.2f

* Weight 24: 0.4*(65+24) = 35.6f main, 0.4*(65-24) = 16.4f diff
Cmain8 cap_topplate cap_botplate_main[8] capacitor c=35.6f
Cdiff8 cap_topplate cap_botplate_diff[8] capacitor c=16.4f

* Weight 12: 0.4*(65+12) = 30.8f main, 0.4*(65-12) = 21.2f diff
Cmain7 cap_topplate cap_botplate_main[7] capacitor c=30.8f
Cdiff7 cap_topplate cap_botplate_diff[7] capacitor c=21.2f

* Weight 10: 0.4*(65+10) = 30f main, 0.4*(65-10) = 22f diff
Cmain6 cap_topplate cap_botplate_main[6] capacitor c=30f
Cdiff6 cap_topplate cap_botplate_diff[6] capacitor c=22f

* Weight 5: 0.4*(65+5) = 28f main, 0.4*(65-5) = 24f diff
Cmain5 cap_topplate cap_botplate_main[5] capacitor c=28f
Cdiff5 cap_topplate cap_botplate_diff[5] capacitor c=24f

* Weight 4: 0.4*(65+4) = 27.6f main, 0.4*(65-4) = 24.4f diff
Cmain4 cap_topplate cap_botplate_main[4] capacitor c=27.6f
Cdiff4 cap_topplate cap_botplate_diff[4] capacitor c=24.4f

* Weight 4: Same as above
Cmain3 cap_topplate cap_botplate_main[3] capacitor c=27.6f
Cdiff3 cap_topplate cap_botplate_diff[3] capacitor c=24.4f

* Weight 2: 0.4*(65+2) = 26.8f main, 0.4*(65-2) = 25.2f diff
Cmain2 cap_topplate cap_botplate_main[2] capacitor c=26.8f
Cdiff2 cap_topplate cap_botplate_diff[2] capacitor c=25.2f

* Weight 1: 0.4*(65+1) = 26.4f main, 0.4*(65-1) = 25.6f diff
Cmain1 cap_topplate cap_botplate_main[1] capacitor c=26.4f
Cdiff1 cap_topplate cap_botplate_diff[1] capacitor c=25.6f

* Weight 1: Same as above
Cmain0 cap_topplate cap_botplate_main[0] capacitor c=26.4f
Cdiff0 cap_topplate cap_botplate_diff[0] capacitor c=25.6f

.ENDS caparray

* ========== adc_digital.cdl ==========
* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT adc_digital seq_init seq_samp seq_comp seq_update en_init en_samp_p en_samp_n en_comp en_update dac_mode dac_diffcaps dac_astate_p[15] dac_astate_p[14] dac_astate_p[13] dac_astate_p[12] dac_astate_p[11] dac_astate_p[10] dac_astate_p[9] dac_astate_p[8] dac_astate_p[7] dac_astate_p[6] dac_astate_p[5] dac_astate_p[4] dac_astate_p[3] dac_astate_p[2] dac_astate_p[1] dac_astate_p[0] dac_bstate_p[15] dac_bstate_p[14] dac_bstate_p[13] dac_bstate_p[12] dac_bstate_p[11] dac_bstate_p[10] dac_bstate_p[9] dac_bstate_p[8] dac_bstate_p[7] dac_bstate_p[6] dac_bstate_p[5] dac_bstate_p[4] dac_bstate_p[3] dac_bstate_p[2] dac_bstate_p[1] dac_bstate_p[0] dac_astate_n[15] dac_astate_n[14] dac_astate_n[13] dac_astate_n[12] dac_astate_n[11] dac_astate_n[10] dac_astate_n[9] dac_astate_n[8] dac_astate_n[7] dac_astate_n[6] dac_astate_n[5] dac_astate_n[4] dac_astate_n[3] dac_astate_n[2] dac_astate_n[1] dac_astate_n[0] dac_bstate_n[15] dac_bstate_n[14] dac_bstate_n[13] dac_bstate_n[12] dac_bstate_n[11] dac_bstate_n[10] dac_bstate_n[9] dac_bstate_n[8] dac_bstate_n[7] dac_bstate_n[6] dac_bstate_n[5] dac_bstate_n[4] dac_bstate_n[3] dac_bstate_n[2] dac_bstate_n[1] dac_bstate_n[0] comp_out_p comp_out_n clk_samp_p clk_samp_p_b clk_samp_n clk_samp_n_b clk_comp dac_state_p_main[15] dac_state_p_main[14] dac_state_p_main[13] dac_state_p_main[12] dac_state_p_main[11] dac_state_p_main[10] dac_state_p_main[9] dac_state_p_main[8] dac_state_p_main[7] dac_state_p_main[6] dac_state_p_main[5] dac_state_p_main[4] dac_state_p_main[3] dac_state_p_main[2] dac_state_p_main[1] dac_state_p_main[0] dac_state_p_diff[15] dac_state_p_diff[14] dac_state_p_diff[13] dac_state_p_diff[12] dac_state_p_diff[11] dac_state_p_diff[10] dac_state_p_diff[9] dac_state_p_diff[8] dac_state_p_diff[7] dac_state_p_diff[6] dac_state_p_diff[5] dac_state_p_diff[4] dac_state_p_diff[3] dac_state_p_diff[2] dac_state_p_diff[1] dac_state_p_diff[0] dac_state_n_main[15] dac_state_n_main[14] dac_state_n_main[13] dac_state_n_main[12] dac_state_n_main[11] dac_state_n_main[10] dac_state_n_main[9] dac_state_n_main[8] dac_state_n_main[7] dac_state_n_main[6] dac_state_n_main[5] dac_state_n_main[4] dac_state_n_main[3] dac_state_n_main[2] dac_state_n_main[1] dac_state_n_main[0] dac_state_n_diff[15] dac_state_n_diff[14] dac_state_n_diff[13] dac_state_n_diff[12] dac_state_n_diff[11] dac_state_n_diff[10] dac_state_n_diff[9] dac_state_n_diff[8] dac_state_n_diff[7] dac_state_n_diff[6] dac_state_n_diff[5] dac_state_n_diff[4] dac_state_n_diff[3] dac_state_n_diff[2] dac_state_n_diff[1] dac_state_n_diff[0] dac_invert_p_main dac_invert_p_diff dac_invert_n_main dac_invert_n_diff comp_out vdd_d vss_d
*.PININFO seq_init:I seq_samp:I seq_comp:I seq_update:I en_init:I en_samp_p:I en_samp_n:I en_comp:I en_update:I dac_mode:I dac_diffcaps:I dac_astate_p[15]:I dac_astate_p[14]:I dac_astate_p[13]:I dac_astate_p[12]:I dac_astate_p[11]:I dac_astate_p[10]:I dac_astate_p[9]:I dac_astate_p[8]:I dac_astate_p[7]:I dac_astate_p[6]:I dac_astate_p[5]:I dac_astate_p[4]:I dac_astate_p[3]:I dac_astate_p[2]:I dac_astate_p[1]:I dac_astate_p[0]:I dac_bstate_p[15]:I dac_bstate_p[14]:I dac_bstate_p[13]:I dac_bstate_p[12]:I dac_bstate_p[11]:I dac_bstate_p[10]:I dac_bstate_p[9]:I dac_bstate_p[8]:I dac_bstate_p[7]:I dac_bstate_p[6]:I dac_bstate_p[5]:I dac_bstate_p[4]:I dac_bstate_p[3]:I dac_bstate_p[2]:I dac_bstate_p[1]:I dac_bstate_p[0]:I dac_astate_n[15]:I dac_astate_n[14]:I dac_astate_n[13]:I dac_astate_n[12]:I dac_astate_n[11]:I dac_astate_n[10]:I dac_astate_n[9]:I dac_astate_n[8]:I dac_astate_n[7]:I dac_astate_n[6]:I dac_astate_n[5]:I dac_astate_n[4]:I dac_astate_n[3]:I dac_astate_n[2]:I dac_astate_n[1]:I dac_astate_n[0]:I dac_bstate_n[15]:I dac_bstate_n[14]:I dac_bstate_n[13]:I dac_bstate_n[12]:I dac_bstate_n[11]:I dac_bstate_n[10]:I dac_bstate_n[9]:I dac_bstate_n[8]:I dac_bstate_n[7]:I dac_bstate_n[6]:I dac_bstate_n[5]:I dac_bstate_n[4]:I dac_bstate_n[3]:I dac_bstate_n[2]:I dac_bstate_n[1]:I dac_bstate_n[0]:I comp_out_p:I comp_out_n:I clk_samp_p:O clk_samp_p_b:O clk_samp_n:O clk_samp_n_b:O clk_comp:O dac_state_p_main[15]:O dac_state_p_main[14]:O dac_state_p_main[13]:O dac_state_p_main[12]:O dac_state_p_main[11]:O dac_state_p_main[10]:O dac_state_p_main[9]:O dac_state_p_main[8]:O dac_state_p_main[7]:O dac_state_p_main[6]:O dac_state_p_main[5]:O dac_state_p_main[4]:O dac_state_p_main[3]:O dac_state_p_main[2]:O dac_state_p_main[1]:O dac_state_p_main[0]:O dac_state_p_diff[15]:O dac_state_p_diff[14]:O dac_state_p_diff[13]:O dac_state_p_diff[12]:O dac_state_p_diff[11]:O dac_state_p_diff[10]:O dac_state_p_diff[9]:O dac_state_p_diff[8]:O dac_state_p_diff[7]:O dac_state_p_diff[6]:O dac_state_p_diff[5]:O dac_state_p_diff[4]:O dac_state_p_diff[3]:O dac_state_p_diff[2]:O dac_state_p_diff[1]:O dac_state_p_diff[0]:O dac_state_n_main[15]:O dac_state_n_main[14]:O dac_state_n_main[13]:O dac_state_n_main[12]:O dac_state_n_main[11]:O dac_state_n_main[10]:O dac_state_n_main[9]:O dac_state_n_main[8]:O dac_state_n_main[7]:O dac_state_n_main[6]:O dac_state_n_main[5]:O dac_state_n_main[4]:O dac_state_n_main[3]:O dac_state_n_main[2]:O dac_state_n_main[1]:O dac_state_n_main[0]:O dac_state_n_diff[15]:O dac_state_n_diff[14]:O dac_state_n_diff[13]:O dac_state_n_diff[12]:O dac_state_n_diff[11]:O dac_state_n_diff[10]:O dac_state_n_diff[9]:O dac_state_n_diff[8]:O dac_state_n_diff[7]:O dac_state_n_diff[6]:O dac_state_n_diff[5]:O dac_state_n_diff[4]:O dac_state_n_diff[3]:O dac_state_n_diff[2]:O dac_state_n_diff[1]:O dac_state_n_diff[0]:O dac_invert_p_main:O dac_invert_p_diff:O dac_invert_n_main:O dac_invert_n_diff:O comp_out:O vdd_d:B vss_d:B

Xinput47 dac_bstate_n[4] net47 vdd_d vss_d BUFFD2LVT
Xplace139 salogic_dual_dac_ff[9].dac_state_p_ff.D net139
+ vdd_d vss_d CKBD2LVT
X_03_ dac_diffcaps net71 vdd_d vss_d BUFFD0LVT
Xinput46 dac_bstate_n[3] net46 vdd_d vss_d BUFFD2LVT
X_05_ dac_diffcaps net72 vdd_d vss_d BUFFD0LVT
Xinput45 dac_bstate_n[2] net45 vdd_d vss_d BUFFD2LVT
Xplace148 clk_init net148 vdd_d vss_d CKBD2LVT
Xclkbuf_2_2_f_clk_update clknet_0_clk_update clknet_2_2_leaf_clk_update
+ vdd_d vss_d BUFFD12LVT
Xclkload0 clknet_2_1_leaf_clk_update _unconnected_0 vdd_d
+ vss_d INVD1LVT
Xclkload2 clknet_2_3_leaf_clk_update _unconnected_1 vdd_d
+ vss_d INVD0LVT
Xplace140 salogic_dual_dac_ff[7].dac_state_n_ff.D net140
+ vdd_d vss_d CKBD2LVT
Xplace142 salogic_dual_dac_ff[5].dac_state_n_ff.D net142
+ vdd_d vss_d CKBD2LVT
Xplace144 net105 net144 vdd_d vss_d CKBD2LVT
Xplace146 salogic_dual_032_ net146 vdd_d vss_d CKBD2LVT
Xplace149 net148 net149 vdd_d vss_d CKBD2LVT
Xclkbuf_2_0_f_clk_update clknet_0_clk_update clknet_2_0_leaf_clk_update
+ vdd_d vss_d BUFFD12LVT
Xclkbuf_0_clk_update clk_update clknet_0_clk_update vdd_d
+ vss_d BUFFD12LVT
Xclkbuf_2_3_f_clk_update clknet_0_clk_update clknet_2_3_leaf_clk_update
+ vdd_d vss_d BUFFD12LVT
Xclkload1 clknet_2_2_leaf_clk_update _unconnected_2 vdd_d
+ vss_d INVD0LVT
Xplace141 salogic_dual_dac_ff[6].dac_state_n_ff.D net141
+ vdd_d vss_d CKBD2LVT
Xplace143 salogic_dual_dac_ff[4].dac_state_n_ff.D net143
+ vdd_d vss_d CKBD2LVT
Xplace145 salogic_dual_041_ net145 vdd_d vss_d CKBD2LVT
Xplace147 salogic_dual_032_ net147 vdd_d vss_d CKBD2LVT
Xplace150 net69 net150 vdd_d vss_d CKBD2LVT
Xclkbuf_2_1_f_clk_update clknet_0_clk_update clknet_2_1_leaf_clk_update
+ vdd_d vss_d BUFFD12LVT
Xclkgate_clkgate_comp.clkgate_cell _unconnected_3 en_comp
+ seq_comp clk_comp vdd_d vss_d CKLNQD1LVT
Xclkgate_clkgate_init.clkgate_cell _unconnected_4 en_init
+ seq_init clk_init vdd_d vss_d CKLNQD1LVT
Xclkgate_clkgate_samp_n.clkgate_cell _unconnected_5 en_samp_n
+ seq_samp clk_samp_n_raw vdd_d vss_d CKLNQD1LVT
Xclkgate_clkgate_samp_p.clkgate_cell _unconnected_6 en_samp_p
+ seq_samp clk_samp_p_raw vdd_d vss_d CKLNQD1LVT
Xclkgate_clkgate_update.clkgate_cell _unconnected_7 en_update
+ seq_update clk_update vdd_d vss_d CKLNQD1LVT
Xsalogic_dual_174_ salogic_dual_dac_cycle[1] salogic_dual_015_
+ vdd_d vss_d CKND0LVT
Xinput44 dac_bstate_n[1] net44 vdd_d vss_d BUFFD2LVT
Xsalogic_dual_176_ salogic_dual_015_ net149 salogic_dual_000_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_177_ salogic_dual_dac_cycle[11] salogic_dual_017_
+ vdd_d vss_d CKND0LVT
Xsalogic_dual_178_ salogic_dual_017_ net149 salogic_dual_001_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_179_ salogic_dual_dac_cycle[12] salogic_dual_018_
+ vdd_d vss_d CKND0LVT
Xsalogic_dual_180_ salogic_dual_018_ net149 salogic_dual_002_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_181_ salogic_dual_dac_cycle[13] salogic_dual_019_
+ vdd_d vss_d CKND0LVT
Xsalogic_dual_182_ salogic_dual_019_ net149 salogic_dual_003_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_183_ salogic_dual_dac_cycle[14] salogic_dual_020_
+ vdd_d vss_d CKND0LVT
Xsalogic_dual_184_ salogic_dual_020_ net148 salogic_dual_004_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_185_ salogic_dual_dac_cycle[15] salogic_dual_021_
+ vdd_d vss_d CKND0LVT
Xsalogic_dual_186_ salogic_dual_021_ net148 salogic_dual_005_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_187_ salogic_dual_dac_cycle[2] salogic_dual_022_
+ vdd_d vss_d CKND0LVT
Xsalogic_dual_188_ salogic_dual_022_ net149 salogic_dual_006_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_189_ salogic_dual_dac_cycle[3] salogic_dual_023_
+ vdd_d vss_d CKND0LVT
Xsalogic_dual_190_ salogic_dual_023_ net149 salogic_dual_007_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_191_ salogic_dual_dac_cycle[4] salogic_dual_024_
+ vdd_d vss_d CKND0LVT
Xsalogic_dual_192_ salogic_dual_024_ net148 salogic_dual_008_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_193_ salogic_dual_dac_cycle[5] salogic_dual_025_
+ vdd_d vss_d CKND0LVT
Xsalogic_dual_194_ salogic_dual_025_ net148 salogic_dual_009_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_195_ salogic_dual_dac_cycle[6] salogic_dual_026_
+ vdd_d vss_d CKND0LVT
Xsalogic_dual_196_ salogic_dual_026_ net148 salogic_dual_010_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_197_ salogic_dual_dac_cycle[7] salogic_dual_027_
+ vdd_d vss_d CKND0LVT
Xsalogic_dual_198_ salogic_dual_027_ net148 salogic_dual_011_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_199_ salogic_dual_dac_cycle[8] salogic_dual_028_
+ vdd_d vss_d CKND0LVT
Xsalogic_dual_200_ salogic_dual_028_ net149 salogic_dual_012_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_201_ salogic_dual_dac_cycle[9] salogic_dual_029_
+ vdd_d vss_d CKND0LVT
Xsalogic_dual_202_ salogic_dual_029_ net149 salogic_dual_013_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_203_ salogic_dual_dac_cycle[10] salogic_dual_030_
+ vdd_d vss_d CKND0LVT
Xsalogic_dual_204_ salogic_dual_030_ net149 salogic_dual_014_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_205_ net150 net4 salogic_dual_031_ vdd_d vss_d
+ CKND2D0LVT
Xsalogic_dual_206_ net148 salogic_dual_032_ vdd_d vss_d
+ INVD2LVT
Xsalogic_dual_207_ salogic_dual_031_ salogic_dual_032_
+ salogic_dual_033_ vdd_d vss_d ND2D2LVT
Xinput43 dac_bstate_n[15] net43 vdd_d vss_d BUFFD2LVT
Xsalogic_dual_209_ net37 salogic_dual_035_ vdd_d vss_d CKND0LVT
Xinput42 dac_bstate_n[14] net42 vdd_d vss_d BUFFD2LVT
Xsalogic_dual_211_ salogic_dual_035_ net150 salogic_dual_037_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_212_ salogic_dual_033_ salogic_dual_037_
+ salogic_dual_038_ vdd_d vss_d NR2D1LVT
Xinput41 dac_bstate_n[13] net41 vdd_d vss_d BUFFD2LVT
Xsalogic_dual_214_ net146 net5 salogic_dual_040_ vdd_d vss_d
+ NR2D0LVT
Xsalogic_dual_215_ salogic_dual_038_ salogic_dual_040_
+ salogic_dual_dac_ff[0].dac_state_n_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_216_ net150 net149 salogic_dual_041_ vdd_d
+ vss_d INR2D2LVT
Xinput40 dac_bstate_n[12] net40 vdd_d vss_d BUFFD2LVT
Xsalogic_dual_218_ salogic_dual_dac_cycle[0] salogic_dual_041_
+ salogic_dual_dac_ff[0].dac_state_n_ff.E vdd_d vss_d IND2D0LVT
Xsalogic_dual_219_ net3 net69 salogic_dual_043_ vdd_d vss_d
+ CKND2D0LVT
Xsalogic_dual_220_ salogic_dual_043_ net147 salogic_dual_044_
+ vdd_d vss_d ND2D2LVT
Xinput39 dac_bstate_n[11] net39 vdd_d vss_d BUFFD2LVT
Xsalogic_dual_222_ net53 salogic_dual_046_ vdd_d vss_d CKND0LVT
Xsalogic_dual_223_ salogic_dual_046_ net69 salogic_dual_047_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_224_ salogic_dual_044_ salogic_dual_047_
+ salogic_dual_048_ vdd_d vss_d NR2D1LVT
Xsalogic_dual_225_ net147 net21 salogic_dual_049_ vdd_d
+ vss_d NR2D0LVT
Xsalogic_dual_226_ salogic_dual_048_ salogic_dual_049_
+ salogic_dual_dac_ff[0].dac_state_p_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_227_ net38 salogic_dual_050_ vdd_d vss_d CKND0LVT
Xsalogic_dual_228_ salogic_dual_050_ net150 salogic_dual_051_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_229_ salogic_dual_033_ salogic_dual_051_
+ salogic_dual_052_ vdd_d vss_d NR2D1LVT
Xsalogic_dual_230_ net146 net6 salogic_dual_053_ vdd_d vss_d
+ NR2D0LVT
Xsalogic_dual_231_ salogic_dual_052_ salogic_dual_053_
+ salogic_dual_dac_ff[10].dac_state_n_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_232_ net145 salogic_dual_030_ salogic_dual_dac_ff[10].dac_state_n_ff.E
+ vdd_d vss_d CKND2D0LVT
Xsalogic_dual_233_ net54 salogic_dual_054_ vdd_d vss_d CKND0LVT
Xsalogic_dual_234_ salogic_dual_054_ net69 salogic_dual_055_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_235_ salogic_dual_044_ salogic_dual_055_
+ salogic_dual_056_ vdd_d vss_d NR2D1LVT
Xsalogic_dual_236_ net147 net22 salogic_dual_057_ vdd_d
+ vss_d NR2D0LVT
Xsalogic_dual_237_ salogic_dual_056_ salogic_dual_057_
+ salogic_dual_dac_ff[10].dac_state_p_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_238_ net39 salogic_dual_058_ vdd_d vss_d CKND0LVT
Xsalogic_dual_239_ salogic_dual_058_ net150 salogic_dual_059_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_240_ salogic_dual_033_ salogic_dual_059_
+ salogic_dual_060_ vdd_d vss_d NR2D1LVT
Xsalogic_dual_241_ net146 net7 salogic_dual_061_ vdd_d vss_d
+ NR2D0LVT
Xsalogic_dual_242_ salogic_dual_060_ salogic_dual_061_
+ salogic_dual_dac_ff[11].dac_state_n_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_243_ net145 salogic_dual_017_ salogic_dual_dac_ff[11].dac_state_n_ff.E
+ vdd_d vss_d CKND2D0LVT
Xsalogic_dual_244_ net55 salogic_dual_062_ vdd_d vss_d CKND0LVT
Xsalogic_dual_245_ salogic_dual_062_ net69 salogic_dual_063_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_246_ salogic_dual_044_ salogic_dual_063_
+ salogic_dual_064_ vdd_d vss_d NR2D1LVT
Xsalogic_dual_247_ net147 net23 salogic_dual_065_ vdd_d
+ vss_d NR2D0LVT
Xsalogic_dual_248_ salogic_dual_064_ salogic_dual_065_
+ salogic_dual_dac_ff[11].dac_state_p_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_249_ net40 salogic_dual_066_ vdd_d vss_d CKND0LVT
Xsalogic_dual_250_ salogic_dual_066_ net150 salogic_dual_067_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_251_ salogic_dual_033_ salogic_dual_067_
+ salogic_dual_068_ vdd_d vss_d NR2D1LVT
Xsalogic_dual_252_ net146 net8 salogic_dual_069_ vdd_d vss_d
+ NR2D0LVT
Xsalogic_dual_253_ salogic_dual_068_ salogic_dual_069_
+ salogic_dual_dac_ff[12].dac_state_n_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_254_ net145 salogic_dual_018_ salogic_dual_dac_ff[12].dac_state_n_ff.E
+ vdd_d vss_d CKND2D0LVT
Xsalogic_dual_255_ net56 salogic_dual_070_ vdd_d vss_d CKND0LVT
Xsalogic_dual_256_ salogic_dual_070_ net69 salogic_dual_071_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_257_ salogic_dual_044_ salogic_dual_071_
+ salogic_dual_072_ vdd_d vss_d NR2D1LVT
Xsalogic_dual_258_ net147 net24 salogic_dual_073_ vdd_d
+ vss_d NR2D0LVT
Xsalogic_dual_259_ salogic_dual_072_ salogic_dual_073_
+ salogic_dual_dac_ff[12].dac_state_p_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_260_ net41 salogic_dual_074_ vdd_d vss_d CKND0LVT
Xsalogic_dual_261_ salogic_dual_074_ net150 salogic_dual_075_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_262_ salogic_dual_033_ salogic_dual_075_
+ salogic_dual_076_ vdd_d vss_d NR2D1LVT
Xsalogic_dual_263_ net146 net9 salogic_dual_077_ vdd_d vss_d
+ NR2D0LVT
Xsalogic_dual_264_ salogic_dual_076_ salogic_dual_077_
+ salogic_dual_dac_ff[13].dac_state_n_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_265_ net145 salogic_dual_019_ salogic_dual_dac_ff[13].dac_state_n_ff.E
+ vdd_d vss_d CKND2D0LVT
Xsalogic_dual_266_ net57 salogic_dual_078_ vdd_d vss_d CKND0LVT
Xsalogic_dual_267_ salogic_dual_078_ net69 salogic_dual_079_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_268_ salogic_dual_044_ salogic_dual_079_
+ salogic_dual_080_ vdd_d vss_d NR2D1LVT
Xsalogic_dual_269_ net147 net25 salogic_dual_081_ vdd_d
+ vss_d NR2D0LVT
Xsalogic_dual_270_ salogic_dual_080_ salogic_dual_081_
+ salogic_dual_dac_ff[13].dac_state_p_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_271_ net42 salogic_dual_082_ vdd_d vss_d CKND0LVT
Xinput38 dac_bstate_n[10] net38 vdd_d vss_d BUFFD2LVT
Xsalogic_dual_273_ salogic_dual_082_ net150 salogic_dual_084_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_274_ salogic_dual_033_ salogic_dual_084_
+ salogic_dual_085_ vdd_d vss_d NR2D1LVT
Xinput37 dac_bstate_n[0] net37 vdd_d vss_d BUFFD2LVT
Xsalogic_dual_276_ net146 net10 salogic_dual_087_ vdd_d
+ vss_d NR2XD0LVT
Xsalogic_dual_277_ salogic_dual_085_ salogic_dual_087_
+ salogic_dual_dac_ff[14].dac_state_n_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_278_ net145 salogic_dual_020_ salogic_dual_dac_ff[14].dac_state_n_ff.E
+ vdd_d vss_d CKND2D0LVT
Xsalogic_dual_279_ net58 salogic_dual_088_ vdd_d vss_d CKND0LVT
Xsalogic_dual_280_ salogic_dual_088_ net69 salogic_dual_089_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_281_ salogic_dual_044_ salogic_dual_089_
+ salogic_dual_090_ vdd_d vss_d NR2D1LVT
Xsalogic_dual_282_ net147 net26 salogic_dual_091_ vdd_d
+ vss_d NR2XD0LVT
Xsalogic_dual_283_ salogic_dual_090_ salogic_dual_091_
+ salogic_dual_dac_ff[14].dac_state_p_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_284_ net43 salogic_dual_092_ vdd_d vss_d CKND0LVT
Xsalogic_dual_285_ salogic_dual_092_ net150 salogic_dual_093_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_286_ salogic_dual_033_ salogic_dual_093_
+ salogic_dual_094_ vdd_d vss_d NR2D1LVT
Xsalogic_dual_287_ net146 net11 salogic_dual_095_ vdd_d
+ vss_d NR2XD0LVT
Xsalogic_dual_288_ salogic_dual_094_ salogic_dual_095_
+ salogic_dual_dac_ff[15].dac_state_n_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_289_ net145 salogic_dual_021_ salogic_dual_dac_ff[15].dac_state_n_ff.E
+ vdd_d vss_d CKND2D0LVT
Xsalogic_dual_290_ net59 salogic_dual_096_ vdd_d vss_d CKND0LVT
Xsalogic_dual_291_ salogic_dual_096_ net69 salogic_dual_097_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_292_ salogic_dual_044_ salogic_dual_097_
+ salogic_dual_098_ vdd_d vss_d NR2D1LVT
Xsalogic_dual_293_ net147 net27 salogic_dual_099_ vdd_d
+ vss_d NR2XD0LVT
Xsalogic_dual_294_ salogic_dual_098_ salogic_dual_099_
+ salogic_dual_dac_ff[15].dac_state_p_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_295_ net44 salogic_dual_100_ vdd_d vss_d CKND0LVT
Xsalogic_dual_296_ salogic_dual_100_ net150 salogic_dual_101_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_297_ salogic_dual_033_ salogic_dual_101_
+ salogic_dual_102_ vdd_d vss_d NR2D1LVT
Xsalogic_dual_298_ net146 net12 salogic_dual_103_ vdd_d
+ vss_d NR2XD0LVT
Xsalogic_dual_299_ salogic_dual_102_ salogic_dual_103_
+ salogic_dual_dac_ff[1].dac_state_n_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_300_ salogic_dual_041_ salogic_dual_015_
+ salogic_dual_dac_ff[1].dac_state_n_ff.E vdd_d vss_d CKND2D0LVT
Xsalogic_dual_301_ net60 salogic_dual_104_ vdd_d vss_d CKND0LVT
Xsalogic_dual_302_ salogic_dual_104_ net69 salogic_dual_105_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_303_ salogic_dual_044_ salogic_dual_105_
+ salogic_dual_106_ vdd_d vss_d NR2D1LVT
Xsalogic_dual_304_ net147 net28 salogic_dual_107_ vdd_d
+ vss_d NR2XD0LVT
Xsalogic_dual_305_ salogic_dual_106_ salogic_dual_107_
+ salogic_dual_dac_ff[1].dac_state_p_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_306_ net45 salogic_dual_108_ vdd_d vss_d CKND0LVT
Xsalogic_dual_307_ salogic_dual_108_ net150 salogic_dual_109_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_308_ salogic_dual_033_ salogic_dual_109_
+ salogic_dual_110_ vdd_d vss_d NR2D1LVT
Xsalogic_dual_309_ net146 net13 salogic_dual_111_ vdd_d
+ vss_d NR2XD0LVT
Xsalogic_dual_310_ salogic_dual_110_ salogic_dual_111_
+ salogic_dual_dac_ff[2].dac_state_n_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_311_ salogic_dual_041_ salogic_dual_022_
+ salogic_dual_dac_ff[2].dac_state_n_ff.E vdd_d vss_d CKND2D0LVT
Xsalogic_dual_312_ net61 salogic_dual_112_ vdd_d vss_d CKND0LVT
Xsalogic_dual_313_ salogic_dual_112_ net69 salogic_dual_113_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_314_ salogic_dual_044_ salogic_dual_113_
+ salogic_dual_114_ vdd_d vss_d NR2D1LVT
Xsalogic_dual_315_ net147 net29 salogic_dual_115_ vdd_d
+ vss_d NR2XD0LVT
Xsalogic_dual_316_ salogic_dual_114_ salogic_dual_115_
+ salogic_dual_dac_ff[2].dac_state_p_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_317_ net46 salogic_dual_116_ vdd_d vss_d CKND0LVT
Xsalogic_dual_318_ salogic_dual_116_ net150 salogic_dual_117_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_319_ salogic_dual_033_ salogic_dual_117_
+ salogic_dual_118_ vdd_d vss_d NR2D1LVT
Xsalogic_dual_320_ net146 net14 salogic_dual_119_ vdd_d
+ vss_d NR2XD0LVT
Xsalogic_dual_321_ salogic_dual_118_ salogic_dual_119_
+ salogic_dual_dac_ff[3].dac_state_n_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_322_ salogic_dual_041_ salogic_dual_023_
+ salogic_dual_dac_ff[3].dac_state_n_ff.E vdd_d vss_d CKND2D0LVT
Xsalogic_dual_323_ net62 salogic_dual_120_ vdd_d vss_d CKND0LVT
Xsalogic_dual_324_ salogic_dual_120_ net69 salogic_dual_121_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_325_ salogic_dual_044_ salogic_dual_121_
+ salogic_dual_122_ vdd_d vss_d NR2D1LVT
Xsalogic_dual_326_ net147 net30 salogic_dual_123_ vdd_d
+ vss_d NR2XD0LVT
Xsalogic_dual_327_ salogic_dual_122_ salogic_dual_123_
+ salogic_dual_dac_ff[3].dac_state_p_ff.D vdd_d vss_d NR2D1LVT
Xsalogic_dual_328_ net47 salogic_dual_124_ vdd_d vss_d CKND0LVT
Xinput36 dac_astate_p[9] net36 vdd_d vss_d BUFFD2LVT
Xsalogic_dual_330_ salogic_dual_124_ net150 salogic_dual_126_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_331_ salogic_dual_033_ salogic_dual_126_
+ salogic_dual_127_ vdd_d vss_d NR2D0LVT
Xinput35 dac_astate_p[8] net35 vdd_d vss_d BUFFD2LVT
Xsalogic_dual_333_ net146 net15 salogic_dual_129_ vdd_d
+ vss_d NR2D0LVT
Xsalogic_dual_334_ salogic_dual_127_ salogic_dual_129_
+ salogic_dual_dac_ff[4].dac_state_n_ff.D vdd_d vss_d NR2D0LVT
Xsalogic_dual_335_ salogic_dual_041_ salogic_dual_024_
+ salogic_dual_dac_ff[4].dac_state_n_ff.E vdd_d vss_d CKND2D0LVT
Xsalogic_dual_336_ net63 salogic_dual_130_ vdd_d vss_d CKND0LVT
Xsalogic_dual_337_ salogic_dual_130_ net69 salogic_dual_131_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_338_ salogic_dual_044_ salogic_dual_131_
+ salogic_dual_132_ vdd_d vss_d NR2D0LVT
Xsalogic_dual_339_ net147 net31 salogic_dual_133_ vdd_d
+ vss_d NR2D0LVT
Xsalogic_dual_340_ salogic_dual_132_ salogic_dual_133_
+ salogic_dual_dac_ff[4].dac_state_p_ff.D vdd_d vss_d NR2D0LVT
Xsalogic_dual_341_ net48 salogic_dual_134_ vdd_d vss_d CKND0LVT
Xsalogic_dual_342_ salogic_dual_134_ net150 salogic_dual_135_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_343_ salogic_dual_033_ salogic_dual_135_
+ salogic_dual_136_ vdd_d vss_d NR2D0LVT
Xsalogic_dual_344_ net146 net16 salogic_dual_137_ vdd_d
+ vss_d NR2D0LVT
Xsalogic_dual_345_ salogic_dual_136_ salogic_dual_137_
+ salogic_dual_dac_ff[5].dac_state_n_ff.D vdd_d vss_d NR2D0LVT
Xsalogic_dual_346_ net145 salogic_dual_025_ salogic_dual_dac_ff[5].dac_state_n_ff.E
+ vdd_d vss_d CKND2D0LVT
Xsalogic_dual_347_ net64 salogic_dual_138_ vdd_d vss_d CKND0LVT
Xsalogic_dual_348_ salogic_dual_138_ net69 salogic_dual_139_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_349_ salogic_dual_044_ salogic_dual_139_
+ salogic_dual_140_ vdd_d vss_d NR2D0LVT
Xsalogic_dual_350_ net147 net32 salogic_dual_141_ vdd_d
+ vss_d NR2D0LVT
Xsalogic_dual_351_ salogic_dual_140_ salogic_dual_141_
+ salogic_dual_dac_ff[5].dac_state_p_ff.D vdd_d vss_d NR2D0LVT
Xsalogic_dual_352_ net49 salogic_dual_142_ vdd_d vss_d CKND0LVT
Xsalogic_dual_353_ salogic_dual_142_ net150 salogic_dual_143_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_354_ salogic_dual_033_ salogic_dual_143_
+ salogic_dual_144_ vdd_d vss_d NR2D0LVT
Xsalogic_dual_355_ net146 net17 salogic_dual_145_ vdd_d
+ vss_d NR2D0LVT
Xsalogic_dual_356_ salogic_dual_144_ salogic_dual_145_
+ salogic_dual_dac_ff[6].dac_state_n_ff.D vdd_d vss_d NR2D0LVT
Xsalogic_dual_357_ net145 salogic_dual_026_ salogic_dual_dac_ff[6].dac_state_n_ff.E
+ vdd_d vss_d CKND2D0LVT
Xsalogic_dual_358_ net65 salogic_dual_146_ vdd_d vss_d CKND0LVT
Xsalogic_dual_359_ salogic_dual_146_ net69 salogic_dual_147_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_360_ salogic_dual_044_ salogic_dual_147_
+ salogic_dual_148_ vdd_d vss_d NR2D0LVT
Xsalogic_dual_361_ net147 net33 salogic_dual_149_ vdd_d
+ vss_d NR2D0LVT
Xsalogic_dual_362_ salogic_dual_148_ salogic_dual_149_
+ salogic_dual_dac_ff[6].dac_state_p_ff.D vdd_d vss_d NR2D0LVT
Xsalogic_dual_363_ net50 salogic_dual_150_ vdd_d vss_d CKND0LVT
Xsalogic_dual_364_ salogic_dual_150_ net150 salogic_dual_151_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_365_ salogic_dual_033_ salogic_dual_151_
+ salogic_dual_152_ vdd_d vss_d NR2D0LVT
Xsalogic_dual_366_ net146 net18 salogic_dual_153_ vdd_d
+ vss_d NR2D0LVT
Xsalogic_dual_367_ salogic_dual_152_ salogic_dual_153_
+ salogic_dual_dac_ff[7].dac_state_n_ff.D vdd_d vss_d NR2D0LVT
Xsalogic_dual_368_ net145 salogic_dual_027_ salogic_dual_dac_ff[7].dac_state_n_ff.E
+ vdd_d vss_d CKND2D0LVT
Xsalogic_dual_369_ net66 salogic_dual_154_ vdd_d vss_d CKND0LVT
Xsalogic_dual_370_ salogic_dual_154_ net69 salogic_dual_155_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_371_ salogic_dual_044_ salogic_dual_155_
+ salogic_dual_156_ vdd_d vss_d NR2D0LVT
Xsalogic_dual_372_ net147 net34 salogic_dual_157_ vdd_d
+ vss_d NR2D0LVT
Xsalogic_dual_373_ salogic_dual_156_ salogic_dual_157_
+ salogic_dual_dac_ff[7].dac_state_p_ff.D vdd_d vss_d NR2D0LVT
Xsalogic_dual_374_ net51 salogic_dual_158_ vdd_d vss_d CKND0LVT
Xsalogic_dual_375_ salogic_dual_158_ net150 salogic_dual_159_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_376_ salogic_dual_033_ salogic_dual_159_
+ salogic_dual_160_ vdd_d vss_d NR2D0LVT
Xsalogic_dual_377_ net146 net19 salogic_dual_161_ vdd_d
+ vss_d NR2D0LVT
Xsalogic_dual_378_ salogic_dual_160_ salogic_dual_161_
+ salogic_dual_dac_ff[8].dac_state_n_ff.D vdd_d vss_d NR2D0LVT
Xsalogic_dual_379_ net145 salogic_dual_028_ salogic_dual_dac_ff[8].dac_state_n_ff.E
+ vdd_d vss_d CKND2D0LVT
Xsalogic_dual_380_ net67 salogic_dual_162_ vdd_d vss_d CKND0LVT
Xsalogic_dual_381_ salogic_dual_162_ net69 salogic_dual_163_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_382_ salogic_dual_044_ salogic_dual_163_
+ salogic_dual_164_ vdd_d vss_d NR2D0LVT
Xsalogic_dual_383_ net147 net35 salogic_dual_165_ vdd_d
+ vss_d NR2D0LVT
Xsalogic_dual_384_ salogic_dual_164_ salogic_dual_165_
+ salogic_dual_dac_ff[8].dac_state_p_ff.D vdd_d vss_d NR2D0LVT
Xsalogic_dual_385_ net52 salogic_dual_166_ vdd_d vss_d CKND0LVT
Xsalogic_dual_386_ salogic_dual_166_ net150 salogic_dual_167_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_387_ salogic_dual_033_ salogic_dual_167_
+ salogic_dual_168_ vdd_d vss_d NR2D0LVT
Xsalogic_dual_388_ net146 net20 salogic_dual_169_ vdd_d
+ vss_d NR2D0LVT
Xsalogic_dual_389_ salogic_dual_168_ salogic_dual_169_
+ salogic_dual_dac_ff[9].dac_state_n_ff.D vdd_d vss_d NR2D0LVT
Xsalogic_dual_390_ net145 salogic_dual_029_ salogic_dual_dac_ff[9].dac_state_n_ff.E
+ vdd_d vss_d CKND2D0LVT
Xsalogic_dual_391_ net68 salogic_dual_170_ vdd_d vss_d CKND0LVT
Xsalogic_dual_392_ salogic_dual_170_ net69 salogic_dual_171_
+ vdd_d vss_d NR2D0LVT
Xsalogic_dual_393_ salogic_dual_044_ salogic_dual_171_
+ salogic_dual_172_ vdd_d vss_d NR2D0LVT
Xsalogic_dual_394_ net147 net36 salogic_dual_173_ vdd_d
+ vss_d NR2D0LVT
Xsalogic_dual_395_ salogic_dual_172_ salogic_dual_173_
+ salogic_dual_dac_ff[9].dac_state_p_ff.D vdd_d vss_d NR2D0LVT
Xinput34 dac_astate_p[7] net34 vdd_d vss_d BUFFD2LVT
Xinput33 dac_astate_p[6] net33 vdd_d vss_d BUFFD2LVT
Xinput32 dac_astate_p[5] net32 vdd_d vss_d BUFFD2LVT
Xinput31 dac_astate_p[4] net31 vdd_d vss_d BUFFD2LVT
Xinput30 dac_astate_p[3] net30 vdd_d vss_d BUFFD2LVT
Xinput29 dac_astate_p[2] net29 vdd_d vss_d BUFFD2LVT
Xinput28 dac_astate_p[1] net28 vdd_d vss_d BUFFD2LVT
Xinput27 dac_astate_p[15] net27 vdd_d vss_d BUFFD2LVT
Xinput26 dac_astate_p[14] net26 vdd_d vss_d BUFFD2LVT
Xinput25 dac_astate_p[13] net25 vdd_d vss_d BUFFD2LVT
Xinput24 dac_astate_p[12] net24 vdd_d vss_d BUFFD2LVT
Xinput23 dac_astate_p[11] net23 vdd_d vss_d BUFFD2LVT
Xinput22 dac_astate_p[10] net22 vdd_d vss_d BUFFD2LVT
Xinput21 dac_astate_p[0] net21 vdd_d vss_d BUFFD2LVT
Xinput20 dac_astate_n[9] net20 vdd_d vss_d BUFFD2LVT
Xinput19 dac_astate_n[8] net19 vdd_d vss_d BUFFD2LVT
Xinput18 dac_astate_n[7] net18 vdd_d vss_d BUFFD2LVT
Xinput17 dac_astate_n[6] net17 vdd_d vss_d BUFFD2LVT
Xinput16 dac_astate_n[5] net16 vdd_d vss_d BUFFD2LVT
Xinput15 dac_astate_n[4] net15 vdd_d vss_d BUFFD2LVT
Xinput14 dac_astate_n[3] net14 vdd_d vss_d BUFFD2LVT
Xinput13 dac_astate_n[2] net13 vdd_d vss_d BUFFD2LVT
Xinput12 dac_astate_n[1] net12 vdd_d vss_d BUFFD2LVT
Xinput11 dac_astate_n[15] net11 vdd_d vss_d BUFFD2LVT
Xinput10 dac_astate_n[14] net10 vdd_d vss_d BUFFD2LVT
Xinput9 dac_astate_n[13] net9 vdd_d vss_d BUFFD2LVT
Xinput8 dac_astate_n[12] net8 vdd_d vss_d BUFFD2LVT
Xinput7 dac_astate_n[11] net7 vdd_d vss_d BUFFD2LVT
Xinput6 dac_astate_n[10] net6 vdd_d vss_d BUFFD2LVT
Xinput5 dac_astate_n[0] net5 vdd_d vss_d BUFFD2LVT
Xinput4 comp_out_p net4 vdd_d vss_d BUFFD2LVT
Xinput3 comp_out_n net3 vdd_d vss_d BUFFD2LVT
Xsalogic_dual_dac_cycle[0]$_SDFF_PP0_ salogic_dual_000_
+ clknet_2_2_leaf_clk_update salogic_dual_dac_cycle[0] vdd_d
+ vss_d DFQD1LVT
Xsalogic_dual_dac_cycle[10]$_SDFF_PP0_ salogic_dual_001_
+ clknet_2_3_leaf_clk_update salogic_dual_dac_cycle[10] vdd_d
+ vss_d DFQD1LVT
Xsalogic_dual_dac_cycle[11]$_SDFF_PP0_ salogic_dual_002_
+ clknet_2_3_leaf_clk_update salogic_dual_dac_cycle[11] vdd_d
+ vss_d DFQD1LVT
Xsalogic_dual_dac_cycle[12]$_SDFF_PP0_ salogic_dual_003_
+ clknet_2_3_leaf_clk_update salogic_dual_dac_cycle[12] vdd_d
+ vss_d DFQD1LVT
Xsalogic_dual_dac_cycle[13]$_SDFF_PP0_ salogic_dual_004_
+ clknet_2_1_leaf_clk_update salogic_dual_dac_cycle[13] vdd_d
+ vss_d DFQD1LVT
Xsalogic_dual_dac_cycle[14]$_SDFF_PP0_ salogic_dual_005_
+ clknet_2_1_leaf_clk_update salogic_dual_dac_cycle[14] vdd_d
+ vss_d DFQD1LVT
Xsalogic_dual_dac_cycle[15]$_DFF_P_ net148 clknet_2_1_leaf_clk_update
+ salogic_dual_dac_cycle[15] vdd_d vss_d DFQD1LVT
Xsalogic_dual_dac_cycle[1]$_SDFF_PP0_ salogic_dual_006_
+ clknet_2_2_leaf_clk_update salogic_dual_dac_cycle[1] vdd_d
+ vss_d DFQD1LVT
Xsalogic_dual_dac_cycle[2]$_SDFF_PP0_ salogic_dual_007_
+ clknet_2_0_leaf_clk_update salogic_dual_dac_cycle[2] vdd_d
+ vss_d DFQD1LVT
Xsalogic_dual_dac_cycle[3]$_SDFF_PP0_ salogic_dual_008_
+ clknet_2_0_leaf_clk_update salogic_dual_dac_cycle[3] vdd_d
+ vss_d DFQD1LVT
Xsalogic_dual_dac_cycle[4]$_SDFF_PP0_ salogic_dual_009_
+ clknet_2_0_leaf_clk_update salogic_dual_dac_cycle[4] vdd_d
+ vss_d DFQD1LVT
Xsalogic_dual_dac_cycle[5]$_SDFF_PP0_ salogic_dual_010_
+ clknet_2_0_leaf_clk_update salogic_dual_dac_cycle[5] vdd_d
+ vss_d DFQD1LVT
Xsalogic_dual_dac_cycle[6]$_SDFF_PP0_ salogic_dual_011_
+ clknet_2_0_leaf_clk_update salogic_dual_dac_cycle[6] vdd_d
+ vss_d DFQD1LVT
Xsalogic_dual_dac_cycle[7]$_SDFF_PP0_ salogic_dual_012_
+ clknet_2_1_leaf_clk_update salogic_dual_dac_cycle[7] vdd_d
+ vss_d DFQD1LVT
Xsalogic_dual_dac_cycle[8]$_SDFF_PP0_ salogic_dual_013_
+ clknet_2_0_leaf_clk_update salogic_dual_dac_cycle[8] vdd_d
+ vss_d DFQD1LVT
Xsalogic_dual_dac_cycle[9]$_SDFF_PP0_ salogic_dual_014_
+ clknet_2_3_leaf_clk_update salogic_dual_dac_cycle[9] vdd_d
+ vss_d DFQD1LVT
Xsalogic_dual_dac_ff[0].dac_state_n_ff.dffe salogic_dual_dac_ff[0].dac_state_n_ff.D
+ salogic_dual_dac_ff[0].dac_state_n_ff.E clknet_2_2_leaf_clk_update
+ net73 _unconnected_8 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[0].dac_state_p_ff.dffe salogic_dual_dac_ff[0].dac_state_p_ff.D
+ salogic_dual_dac_ff[0].dac_state_n_ff.E clknet_2_2_leaf_clk_update
+ net105 _unconnected_9 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[10].dac_state_n_ff.dffe salogic_dual_dac_ff[10].dac_state_n_ff.D
+ salogic_dual_dac_ff[10].dac_state_n_ff.E clknet_2_3_leaf_clk_update
+ net74 _unconnected_10 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[10].dac_state_p_ff.dffe salogic_dual_dac_ff[10].dac_state_p_ff.D
+ salogic_dual_dac_ff[10].dac_state_n_ff.E clknet_2_3_leaf_clk_update
+ net106 _unconnected_11 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[11].dac_state_n_ff.dffe salogic_dual_dac_ff[11].dac_state_n_ff.D
+ salogic_dual_dac_ff[11].dac_state_n_ff.E clknet_2_3_leaf_clk_update
+ net75 _unconnected_12 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[11].dac_state_p_ff.dffe salogic_dual_dac_ff[11].dac_state_p_ff.D
+ salogic_dual_dac_ff[11].dac_state_n_ff.E clknet_2_3_leaf_clk_update
+ net107 _unconnected_13 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[12].dac_state_n_ff.dffe salogic_dual_dac_ff[12].dac_state_n_ff.D
+ salogic_dual_dac_ff[12].dac_state_n_ff.E clknet_2_3_leaf_clk_update
+ net76 _unconnected_14 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[12].dac_state_p_ff.dffe salogic_dual_dac_ff[12].dac_state_p_ff.D
+ salogic_dual_dac_ff[12].dac_state_n_ff.E clknet_2_3_leaf_clk_update
+ net108 _unconnected_15 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[13].dac_state_n_ff.dffe salogic_dual_dac_ff[13].dac_state_n_ff.D
+ salogic_dual_dac_ff[13].dac_state_n_ff.E clknet_2_3_leaf_clk_update
+ net77 _unconnected_16 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[13].dac_state_p_ff.dffe salogic_dual_dac_ff[13].dac_state_p_ff.D
+ salogic_dual_dac_ff[13].dac_state_n_ff.E clknet_2_1_leaf_clk_update
+ net109 _unconnected_17 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[14].dac_state_n_ff.dffe salogic_dual_dac_ff[14].dac_state_n_ff.D
+ salogic_dual_dac_ff[14].dac_state_n_ff.E clknet_2_1_leaf_clk_update
+ net78 _unconnected_18 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[14].dac_state_p_ff.dffe salogic_dual_dac_ff[14].dac_state_p_ff.D
+ salogic_dual_dac_ff[14].dac_state_n_ff.E clknet_2_1_leaf_clk_update
+ net110 _unconnected_19 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[15].dac_state_n_ff.dffe salogic_dual_dac_ff[15].dac_state_n_ff.D
+ salogic_dual_dac_ff[15].dac_state_n_ff.E clknet_2_1_leaf_clk_update
+ net79 _unconnected_20 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[15].dac_state_p_ff.dffe salogic_dual_dac_ff[15].dac_state_p_ff.D
+ salogic_dual_dac_ff[15].dac_state_n_ff.E clknet_2_1_leaf_clk_update
+ net111 _unconnected_21 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[1].dac_state_n_ff.dffe salogic_dual_dac_ff[1].dac_state_n_ff.D
+ salogic_dual_dac_ff[1].dac_state_n_ff.E clknet_2_2_leaf_clk_update
+ net80 _unconnected_22 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[1].dac_state_p_ff.dffe salogic_dual_dac_ff[1].dac_state_p_ff.D
+ salogic_dual_dac_ff[1].dac_state_n_ff.E clknet_2_2_leaf_clk_update
+ net112 _unconnected_23 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[2].dac_state_n_ff.dffe salogic_dual_dac_ff[2].dac_state_n_ff.D
+ salogic_dual_dac_ff[2].dac_state_n_ff.E clknet_2_2_leaf_clk_update
+ net81 _unconnected_24 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[2].dac_state_p_ff.dffe salogic_dual_dac_ff[2].dac_state_p_ff.D
+ salogic_dual_dac_ff[2].dac_state_n_ff.E clknet_2_2_leaf_clk_update
+ net113 _unconnected_25 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[3].dac_state_n_ff.dffe salogic_dual_dac_ff[3].dac_state_n_ff.D
+ salogic_dual_dac_ff[3].dac_state_n_ff.E clknet_2_2_leaf_clk_update
+ net82 _unconnected_26 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[3].dac_state_p_ff.dffe salogic_dual_dac_ff[3].dac_state_p_ff.D
+ salogic_dual_dac_ff[3].dac_state_n_ff.E clknet_2_0_leaf_clk_update
+ net114 _unconnected_27 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[4].dac_state_n_ff.dffe net143 salogic_dual_dac_ff[4].dac_state_n_ff.E
+ clknet_2_2_leaf_clk_update net83 _unconnected_28 vdd_d vss_d
+ EDFD2LVT
Xsalogic_dual_dac_ff[4].dac_state_p_ff.dffe salogic_dual_dac_ff[4].dac_state_p_ff.D
+ salogic_dual_dac_ff[4].dac_state_n_ff.E clknet_2_0_leaf_clk_update
+ net115 _unconnected_29 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[5].dac_state_n_ff.dffe net142 salogic_dual_dac_ff[5].dac_state_n_ff.E
+ clknet_2_0_leaf_clk_update net84 _unconnected_30 vdd_d vss_d
+ EDFD2LVT
Xsalogic_dual_dac_ff[5].dac_state_p_ff.dffe salogic_dual_dac_ff[5].dac_state_p_ff.D
+ salogic_dual_dac_ff[5].dac_state_n_ff.E clknet_2_0_leaf_clk_update
+ net116 _unconnected_31 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[6].dac_state_n_ff.dffe net141 salogic_dual_dac_ff[6].dac_state_n_ff.E
+ clknet_2_0_leaf_clk_update net85 _unconnected_32 vdd_d vss_d
+ EDFD2LVT
Xsalogic_dual_dac_ff[6].dac_state_p_ff.dffe salogic_dual_dac_ff[6].dac_state_p_ff.D
+ salogic_dual_dac_ff[6].dac_state_n_ff.E clknet_2_0_leaf_clk_update
+ net117 _unconnected_33 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[7].dac_state_n_ff.dffe net140 salogic_dual_dac_ff[7].dac_state_n_ff.E
+ clknet_2_1_leaf_clk_update net86 _unconnected_34 vdd_d vss_d
+ EDFD2LVT
Xsalogic_dual_dac_ff[7].dac_state_p_ff.dffe salogic_dual_dac_ff[7].dac_state_p_ff.D
+ salogic_dual_dac_ff[7].dac_state_n_ff.E clknet_2_1_leaf_clk_update
+ net118 _unconnected_35 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[8].dac_state_n_ff.dffe salogic_dual_dac_ff[8].dac_state_n_ff.D
+ salogic_dual_dac_ff[8].dac_state_n_ff.E clknet_2_3_leaf_clk_update
+ net87 _unconnected_36 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[8].dac_state_p_ff.dffe salogic_dual_dac_ff[8].dac_state_p_ff.D
+ salogic_dual_dac_ff[8].dac_state_n_ff.E clknet_2_0_leaf_clk_update
+ net119 _unconnected_37 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[9].dac_state_n_ff.dffe salogic_dual_dac_ff[9].dac_state_n_ff.D
+ salogic_dual_dac_ff[9].dac_state_n_ff.E clknet_2_2_leaf_clk_update
+ net88 _unconnected_38 vdd_d vss_d EDFD2LVT
Xsalogic_dual_dac_ff[9].dac_state_p_ff.dffe net139 salogic_dual_dac_ff[9].dac_state_n_ff.E
+ clknet_2_2_leaf_clk_update net120 _unconnected_39 vdd_d vss_d
+ EDFD2LVT
Xsampdriver_n_clk_buf.buf_cell clk_samp_n_raw clk_samp_n vdd_d
+ vss_d BUFFD2LVT
Xsampdriver_n_clk_inv.inv_cell clk_samp_n_raw clk_samp_n_b
+ vdd_d vss_d INVD2LVT
Xsampdriver_p_clk_buf.buf_cell clk_samp_p_raw clk_samp_p vdd_d
+ vss_d BUFFD2LVT
Xsampdriver_p_clk_inv.inv_cell clk_samp_p_raw clk_samp_p_b
+ vdd_d vss_d INVD2LVT
X_04_1 dac_invert_n_main vdd_d vss_d TIELLVT
X_06_2 dac_invert_p_main vdd_d vss_d TIELLVT
Xinput48 dac_bstate_n[5] net48 vdd_d vss_d BUFFD2LVT
Xinput49 dac_bstate_n[6] net49 vdd_d vss_d BUFFD2LVT
Xinput50 dac_bstate_n[7] net50 vdd_d vss_d BUFFD2LVT
Xinput51 dac_bstate_n[8] net51 vdd_d vss_d BUFFD2LVT
Xinput52 dac_bstate_n[9] net52 vdd_d vss_d BUFFD2LVT
Xinput53 dac_bstate_p[0] net53 vdd_d vss_d BUFFD2LVT
Xinput54 dac_bstate_p[10] net54 vdd_d vss_d BUFFD2LVT
Xinput55 dac_bstate_p[11] net55 vdd_d vss_d BUFFD2LVT
Xinput56 dac_bstate_p[12] net56 vdd_d vss_d BUFFD2LVT
Xinput57 dac_bstate_p[13] net57 vdd_d vss_d BUFFD2LVT
Xinput58 dac_bstate_p[14] net58 vdd_d vss_d BUFFD2LVT
Xinput59 dac_bstate_p[15] net59 vdd_d vss_d BUFFD2LVT
Xinput60 dac_bstate_p[1] net60 vdd_d vss_d BUFFD2LVT
Xinput61 dac_bstate_p[2] net61 vdd_d vss_d BUFFD2LVT
Xinput62 dac_bstate_p[3] net62 vdd_d vss_d BUFFD2LVT
Xinput63 dac_bstate_p[4] net63 vdd_d vss_d BUFFD2LVT
Xinput64 dac_bstate_p[5] net64 vdd_d vss_d BUFFD2LVT
Xinput65 dac_bstate_p[6] net65 vdd_d vss_d BUFFD2LVT
Xinput66 dac_bstate_p[7] net66 vdd_d vss_d BUFFD2LVT
Xinput67 dac_bstate_p[8] net67 vdd_d vss_d BUFFD2LVT
Xinput68 dac_bstate_p[9] net68 vdd_d vss_d BUFFD2LVT
Xinput69 dac_mode net69 vdd_d vss_d BUFFD2LVT
Xoutput70 net4 comp_out vdd_d vss_d BUFFD2LVT
Xoutput71 net71 dac_invert_n_diff vdd_d vss_d BUFFD2LVT
Xoutput72 net72 dac_invert_p_diff vdd_d vss_d BUFFD2LVT
Xoutput73 net73 dac_state_n_diff[0] vdd_d vss_d BUFFD2LVT
Xoutput74 net74 dac_state_n_diff[10] vdd_d vss_d BUFFD2LVT
Xoutput75 net75 dac_state_n_diff[11] vdd_d vss_d BUFFD2LVT
Xoutput76 net76 dac_state_n_diff[12] vdd_d vss_d BUFFD2LVT
Xoutput77 net77 dac_state_n_diff[13] vdd_d vss_d BUFFD2LVT
Xoutput78 net78 dac_state_n_diff[14] vdd_d vss_d BUFFD2LVT
Xoutput79 net79 dac_state_n_diff[15] vdd_d vss_d BUFFD2LVT
Xoutput80 net80 dac_state_n_diff[1] vdd_d vss_d BUFFD2LVT
Xoutput81 net81 dac_state_n_diff[2] vdd_d vss_d BUFFD2LVT
Xoutput82 net82 dac_state_n_diff[3] vdd_d vss_d BUFFD2LVT
Xoutput83 net83 dac_state_n_diff[4] vdd_d vss_d BUFFD2LVT
Xoutput84 net84 dac_state_n_diff[5] vdd_d vss_d BUFFD2LVT
Xoutput85 net85 dac_state_n_diff[6] vdd_d vss_d BUFFD2LVT
Xoutput86 net86 dac_state_n_diff[7] vdd_d vss_d BUFFD2LVT
Xoutput87 net87 dac_state_n_diff[8] vdd_d vss_d BUFFD2LVT
Xoutput88 net88 dac_state_n_diff[9] vdd_d vss_d BUFFD2LVT
Xoutput89 net73 dac_state_n_main[0] vdd_d vss_d BUFFD2LVT
Xoutput90 net74 dac_state_n_main[10] vdd_d vss_d BUFFD2LVT
Xoutput91 net75 dac_state_n_main[11] vdd_d vss_d BUFFD2LVT
Xoutput92 net76 dac_state_n_main[12] vdd_d vss_d BUFFD2LVT
Xoutput93 net77 dac_state_n_main[13] vdd_d vss_d BUFFD2LVT
Xoutput94 net78 dac_state_n_main[14] vdd_d vss_d BUFFD2LVT
Xoutput95 net79 dac_state_n_main[15] vdd_d vss_d BUFFD2LVT
Xoutput96 net80 dac_state_n_main[1] vdd_d vss_d BUFFD2LVT
Xoutput97 net81 dac_state_n_main[2] vdd_d vss_d BUFFD2LVT
Xoutput98 net82 dac_state_n_main[3] vdd_d vss_d BUFFD2LVT
Xoutput99 net83 dac_state_n_main[4] vdd_d vss_d BUFFD2LVT
Xoutput100 net84 dac_state_n_main[5] vdd_d vss_d BUFFD2LVT
Xoutput101 net85 dac_state_n_main[6] vdd_d vss_d BUFFD2LVT
Xoutput102 net86 dac_state_n_main[7] vdd_d vss_d BUFFD2LVT
Xoutput103 net87 dac_state_n_main[8] vdd_d vss_d BUFFD2LVT
Xoutput104 net88 dac_state_n_main[9] vdd_d vss_d BUFFD2LVT
Xoutput105 net144 dac_state_p_diff[0] vdd_d vss_d BUFFD2LVT
Xoutput106 net106 dac_state_p_diff[10] vdd_d vss_d BUFFD2LVT
Xoutput107 net107 dac_state_p_diff[11] vdd_d vss_d BUFFD2LVT
Xoutput108 net108 dac_state_p_diff[12] vdd_d vss_d BUFFD2LVT
Xoutput109 net109 dac_state_p_diff[13] vdd_d vss_d BUFFD2LVT
Xoutput110 net110 dac_state_p_diff[14] vdd_d vss_d BUFFD2LVT
Xoutput111 net111 dac_state_p_diff[15] vdd_d vss_d BUFFD2LVT
Xoutput112 net112 dac_state_p_diff[1] vdd_d vss_d BUFFD2LVT
Xoutput113 net113 dac_state_p_diff[2] vdd_d vss_d BUFFD2LVT
Xoutput114 net114 dac_state_p_diff[3] vdd_d vss_d BUFFD2LVT
Xoutput115 net115 dac_state_p_diff[4] vdd_d vss_d BUFFD2LVT
Xoutput116 net116 dac_state_p_diff[5] vdd_d vss_d BUFFD2LVT
Xoutput117 net117 dac_state_p_diff[6] vdd_d vss_d BUFFD2LVT
Xoutput118 net118 dac_state_p_diff[7] vdd_d vss_d BUFFD2LVT
Xoutput119 net119 dac_state_p_diff[8] vdd_d vss_d BUFFD2LVT
Xoutput120 net120 dac_state_p_diff[9] vdd_d vss_d BUFFD2LVT
Xoutput121 net144 dac_state_p_main[0] vdd_d vss_d BUFFD2LVT
Xoutput122 net106 dac_state_p_main[10] vdd_d vss_d BUFFD2LVT
Xoutput123 net107 dac_state_p_main[11] vdd_d vss_d BUFFD2LVT
Xoutput124 net108 dac_state_p_main[12] vdd_d vss_d BUFFD2LVT
Xoutput125 net109 dac_state_p_main[13] vdd_d vss_d BUFFD2LVT
Xoutput126 net110 dac_state_p_main[14] vdd_d vss_d BUFFD2LVT
Xoutput127 net111 dac_state_p_main[15] vdd_d vss_d BUFFD2LVT
Xoutput128 net112 dac_state_p_main[1] vdd_d vss_d BUFFD2LVT
Xoutput129 net113 dac_state_p_main[2] vdd_d vss_d BUFFD2LVT
Xoutput130 net114 dac_state_p_main[3] vdd_d vss_d BUFFD2LVT
Xoutput131 net115 dac_state_p_main[4] vdd_d vss_d BUFFD2LVT
Xoutput132 net116 dac_state_p_main[5] vdd_d vss_d BUFFD2LVT
Xoutput133 net117 dac_state_p_main[6] vdd_d vss_d BUFFD2LVT
Xoutput134 net118 dac_state_p_main[7] vdd_d vss_d BUFFD2LVT
Xoutput135 net119 dac_state_p_main[8] vdd_d vss_d BUFFD2LVT
Xoutput136 net120 dac_state_p_main[9] vdd_d vss_d BUFFD2LVT
.ENDS adc_digital

* ========== adc.cdl ==========
* ADC Top-level Module - Complete mixed-signal ADC with connectivity between digital and analog blocks

*.BUSDELIMITER [

.SUBCKT adc seq_init seq_samp seq_comp seq_update comp_out en_init en_samp_p en_samp_n en_comp en_update dac_mode dac_diffcaps dac_astate_p[15] dac_astate_p[14] dac_astate_p[13] dac_astate_p[12] dac_astate_p[11] dac_astate_p[10] dac_astate_p[9] dac_astate_p[8] dac_astate_p[7] dac_astate_p[6] dac_astate_p[5] dac_astate_p[4] dac_astate_p[3] dac_astate_p[2] dac_astate_p[1] dac_astate_p[0] dac_bstate_p[15] dac_bstate_p[14] dac_bstate_p[13] dac_bstate_p[12] dac_bstate_p[11] dac_bstate_p[10] dac_bstate_p[9] dac_bstate_p[8] dac_bstate_p[7] dac_bstate_p[6] dac_bstate_p[5] dac_bstate_p[4] dac_bstate_p[3] dac_bstate_p[2] dac_bstate_p[1] dac_bstate_p[0] dac_astate_n[15] dac_astate_n[14] dac_astate_n[13] dac_astate_n[12] dac_astate_n[11] dac_astate_n[10] dac_astate_n[9] dac_astate_n[8] dac_astate_n[7] dac_astate_n[6] dac_astate_n[5] dac_astate_n[4] dac_astate_n[3] dac_astate_n[2] dac_astate_n[1] dac_astate_n[0] dac_bstate_n[15] dac_bstate_n[14] dac_bstate_n[13] dac_bstate_n[12] dac_bstate_n[11] dac_bstate_n[10] dac_bstate_n[9] dac_bstate_n[8] dac_bstate_n[7] dac_bstate_n[6] dac_bstate_n[5] dac_bstate_n[4] dac_bstate_n[3] dac_bstate_n[2] dac_bstate_n[1] dac_bstate_n[0] vin_p vin_n vdd_a vss_a vdd_d vss_d vdd_dac vss_dac
*.PININFO seq_init:I seq_samp:I seq_comp:I seq_update:I comp_out:O en_init:I en_samp_p:I en_samp_n:I en_comp:I en_update:I dac_mode:I dac_diffcaps:I dac_astate_p[15]:I dac_astate_p[14]:I dac_astate_p[13]:I dac_astate_p[12]:I dac_astate_p[11]:I dac_astate_p[10]:I dac_astate_p[9]:I dac_astate_p[8]:I dac_astate_p[7]:I dac_astate_p[6]:I dac_astate_p[5]:I dac_astate_p[4]:I dac_astate_p[3]:I dac_astate_p[2]:I dac_astate_p[1]:I dac_astate_p[0]:I dac_bstate_p[15]:I dac_bstate_p[14]:I dac_bstate_p[13]:I dac_bstate_p[12]:I dac_bstate_p[11]:I dac_bstate_p[10]:I dac_bstate_p[9]:I dac_bstate_p[8]:I dac_bstate_p[7]:I dac_bstate_p[6]:I dac_bstate_p[5]:I dac_bstate_p[4]:I dac_bstate_p[3]:I dac_bstate_p[2]:I dac_bstate_p[1]:I dac_bstate_p[0]:I dac_astate_n[15]:I dac_astate_n[14]:I dac_astate_n[13]:I dac_astate_n[12]:I dac_astate_n[11]:I dac_astate_n[10]:I dac_astate_n[9]:I dac_astate_n[8]:I dac_astate_n[7]:I dac_astate_n[6]:I dac_astate_n[5]:I dac_astate_n[4]:I dac_astate_n[3]:I dac_astate_n[2]:I dac_astate_n[1]:I dac_astate_n[0]:I dac_bstate_n[15]:I dac_bstate_n[14]:I dac_bstate_n[13]:I dac_bstate_n[12]:I dac_bstate_n[11]:I dac_bstate_n[10]:I dac_bstate_n[9]:I dac_bstate_n[8]:I dac_bstate_n[7]:I dac_bstate_n[6]:I dac_bstate_n[5]:I dac_bstate_n[4]:I dac_bstate_n[3]:I dac_bstate_n[2]:I dac_bstate_n[1]:I dac_bstate_n[0]:I vin_p:B vin_n:B vdd_a:B vss_a:B vdd_d:B vss_d:B vdd_dac:B vss_dac:B

* Internal wire declarations
* Digital clock signals
* clk_samp_p clk_samp_p_b clk_samp_n clk_samp_n_b clk_comp
* DAC state signals from digital block (64 bits total)
* dac_state_p_main[15:0] dac_state_p_diff[15:0] dac_state_n_main[15:0] dac_state_n_diff[15:0]
* DAC invert signals from digital block (4 bits total)
* dac_invert_p_main dac_invert_p_diff dac_invert_n_main dac_invert_n_diff
* Capacitor driver outputs (64 bits total)
* dac_drive_botplate_main_p[15:0] dac_drive_botplate_diff_p[15:0]
* dac_drive_botplate_main_n[15:0] dac_drive_botplate_diff_n[15:0]
* Analog voltage signals (vdac_p/vdac_n connect sampswitch, caparray, and comparator)
* vdac_p vdac_n comp_out_p comp_out_n

* Digital block instance
Xadc_digital seq_init seq_samp seq_comp seq_update en_init en_samp_p en_samp_n en_comp en_update dac_mode dac_diffcaps dac_astate_p[15] dac_astate_p[14] dac_astate_p[13] dac_astate_p[12] dac_astate_p[11] dac_astate_p[10] dac_astate_p[9] dac_astate_p[8] dac_astate_p[7] dac_astate_p[6] dac_astate_p[5] dac_astate_p[4] dac_astate_p[3] dac_astate_p[2] dac_astate_p[1] dac_astate_p[0] dac_bstate_p[15] dac_bstate_p[14] dac_bstate_p[13] dac_bstate_p[12] dac_bstate_p[11] dac_bstate_p[10] dac_bstate_p[9] dac_bstate_p[8] dac_bstate_p[7] dac_bstate_p[6] dac_bstate_p[5] dac_bstate_p[4] dac_bstate_p[3] dac_bstate_p[2] dac_bstate_p[1] dac_bstate_p[0] dac_astate_n[15] dac_astate_n[14] dac_astate_n[13] dac_astate_n[12] dac_astate_n[11] dac_astate_n[10] dac_astate_n[9] dac_astate_n[8] dac_astate_n[7] dac_astate_n[6] dac_astate_n[5] dac_astate_n[4] dac_astate_n[3] dac_astate_n[2] dac_astate_n[1] dac_astate_n[0] dac_bstate_n[15] dac_bstate_n[14] dac_bstate_n[13] dac_bstate_n[12] dac_bstate_n[11] dac_bstate_n[10] dac_bstate_n[9] dac_bstate_n[8] dac_bstate_n[7] dac_bstate_n[6] dac_bstate_n[5] dac_bstate_n[4] dac_bstate_n[3] dac_bstate_n[2] dac_bstate_n[1] dac_bstate_n[0] comp_out_p comp_out_n clk_samp_p clk_samp_p_b clk_samp_n clk_samp_n_b clk_comp dac_state_p_main[15] dac_state_p_main[14] dac_state_p_main[13] dac_state_p_main[12] dac_state_p_main[11] dac_state_p_main[10] dac_state_p_main[9] dac_state_p_main[8] dac_state_p_main[7] dac_state_p_main[6] dac_state_p_main[5] dac_state_p_main[4] dac_state_p_main[3] dac_state_p_main[2] dac_state_p_main[1] dac_state_p_main[0] dac_state_p_diff[15] dac_state_p_diff[14] dac_state_p_diff[13] dac_state_p_diff[12] dac_state_p_diff[11] dac_state_p_diff[10] dac_state_p_diff[9] dac_state_p_diff[8] dac_state_p_diff[7] dac_state_p_diff[6] dac_state_p_diff[5] dac_state_p_diff[4] dac_state_p_diff[3] dac_state_p_diff[2] dac_state_p_diff[1] dac_state_p_diff[0] dac_state_n_main[15] dac_state_n_main[14] dac_state_n_main[13] dac_state_n_main[12] dac_state_n_main[11] dac_state_n_main[10] dac_state_n_main[9] dac_state_n_main[8] dac_state_n_main[7] dac_state_n_main[6] dac_state_n_main[5] dac_state_n_main[4] dac_state_n_main[3] dac_state_n_main[2] dac_state_n_main[1] dac_state_n_main[0] dac_state_n_diff[15] dac_state_n_diff[14] dac_state_n_diff[13] dac_state_n_diff[12] dac_state_n_diff[11] dac_state_n_diff[10] dac_state_n_diff[9] dac_state_n_diff[8] dac_state_n_diff[7] dac_state_n_diff[6] dac_state_n_diff[5] dac_state_n_diff[4] dac_state_n_diff[3] dac_state_n_diff[2] dac_state_n_diff[1] dac_state_n_diff[0] dac_invert_p_main dac_invert_p_diff dac_invert_n_main dac_invert_n_diff comp_out vdd_d vss_d / adc_digital

* Four capacitor driver instances
Xcapdriver_p_main dac_state_p_main[15] dac_state_p_main[14] dac_state_p_main[13] dac_state_p_main[12] dac_state_p_main[11] dac_state_p_main[10] dac_state_p_main[9] dac_state_p_main[8] dac_state_p_main[7] dac_state_p_main[6] dac_state_p_main[5] dac_state_p_main[4] dac_state_p_main[3] dac_state_p_main[2] dac_state_p_main[1] dac_state_p_main[0] dac_invert_p_main dac_drive_botplate_main_p[15] dac_drive_botplate_main_p[14] dac_drive_botplate_main_p[13] dac_drive_botplate_main_p[12] dac_drive_botplate_main_p[11] dac_drive_botplate_main_p[10] dac_drive_botplate_main_p[9] dac_drive_botplate_main_p[8] dac_drive_botplate_main_p[7] dac_drive_botplate_main_p[6] dac_drive_botplate_main_p[5] dac_drive_botplate_main_p[4] dac_drive_botplate_main_p[3] dac_drive_botplate_main_p[2] dac_drive_botplate_main_p[1] dac_drive_botplate_main_p[0] vdd_dac vss_dac / capdriver

Xcapdriver_p_diff dac_state_p_diff[15] dac_state_p_diff[14] dac_state_p_diff[13] dac_state_p_diff[12] dac_state_p_diff[11] dac_state_p_diff[10] dac_state_p_diff[9] dac_state_p_diff[8] dac_state_p_diff[7] dac_state_p_diff[6] dac_state_p_diff[5] dac_state_p_diff[4] dac_state_p_diff[3] dac_state_p_diff[2] dac_state_p_diff[1] dac_state_p_diff[0] dac_invert_p_diff dac_drive_botplate_diff_p[15] dac_drive_botplate_diff_p[14] dac_drive_botplate_diff_p[13] dac_drive_botplate_diff_p[12] dac_drive_botplate_diff_p[11] dac_drive_botplate_diff_p[10] dac_drive_botplate_diff_p[9] dac_drive_botplate_diff_p[8] dac_drive_botplate_diff_p[7] dac_drive_botplate_diff_p[6] dac_drive_botplate_diff_p[5] dac_drive_botplate_diff_p[4] dac_drive_botplate_diff_p[3] dac_drive_botplate_diff_p[2] dac_drive_botplate_diff_p[1] dac_drive_botplate_diff_p[0] vdd_dac vss_dac / capdriver

Xcapdriver_n_main dac_state_n_main[15] dac_state_n_main[14] dac_state_n_main[13] dac_state_n_main[12] dac_state_n_main[11] dac_state_n_main[10] dac_state_n_main[9] dac_state_n_main[8] dac_state_n_main[7] dac_state_n_main[6] dac_state_n_main[5] dac_state_n_main[4] dac_state_n_main[3] dac_state_n_main[2] dac_state_n_main[1] dac_state_n_main[0] dac_invert_n_main dac_drive_botplate_main_n[15] dac_drive_botplate_main_n[14] dac_drive_botplate_main_n[13] dac_drive_botplate_main_n[12] dac_drive_botplate_main_n[11] dac_drive_botplate_main_n[10] dac_drive_botplate_main_n[9] dac_drive_botplate_main_n[8] dac_drive_botplate_main_n[7] dac_drive_botplate_main_n[6] dac_drive_botplate_main_n[5] dac_drive_botplate_main_n[4] dac_drive_botplate_main_n[3] dac_drive_botplate_main_n[2] dac_drive_botplate_main_n[1] dac_drive_botplate_main_n[0] vdd_dac vss_dac / capdriver

Xcapdriver_n_diff dac_state_n_diff[15] dac_state_n_diff[14] dac_state_n_diff[13] dac_state_n_diff[12] dac_state_n_diff[11] dac_state_n_diff[10] dac_state_n_diff[9] dac_state_n_diff[8] dac_state_n_diff[7] dac_state_n_diff[6] dac_state_n_diff[5] dac_state_n_diff[4] dac_state_n_diff[3] dac_state_n_diff[2] dac_state_n_diff[1] dac_state_n_diff[0] dac_invert_n_diff dac_drive_botplate_diff_n[15] dac_drive_botplate_diff_n[14] dac_drive_botplate_diff_n[13] dac_drive_botplate_diff_n[12] dac_drive_botplate_diff_n[11] dac_drive_botplate_diff_n[10] dac_drive_botplate_diff_n[9] dac_drive_botplate_diff_n[8] dac_drive_botplate_diff_n[7] dac_drive_botplate_diff_n[6] dac_drive_botplate_diff_n[5] dac_drive_botplate_diff_n[4] dac_drive_botplate_diff_n[3] dac_drive_botplate_diff_n[2] dac_drive_botplate_diff_n[1] dac_drive_botplate_diff_n[0] vdd_dac vss_dac / capdriver

* Two capacitor array instances (cap_shieldplate connected to vss_a)
Xcaparray_p vdac_p vss_a dac_drive_botplate_main_p[15] dac_drive_botplate_main_p[14] dac_drive_botplate_main_p[13] dac_drive_botplate_main_p[12] dac_drive_botplate_main_p[11] dac_drive_botplate_main_p[10] dac_drive_botplate_main_p[9] dac_drive_botplate_main_p[8] dac_drive_botplate_main_p[7] dac_drive_botplate_main_p[6] dac_drive_botplate_main_p[5] dac_drive_botplate_main_p[4] dac_drive_botplate_main_p[3] dac_drive_botplate_main_p[2] dac_drive_botplate_main_p[1] dac_drive_botplate_main_p[0] dac_drive_botplate_diff_p[15] dac_drive_botplate_diff_p[14] dac_drive_botplate_diff_p[13] dac_drive_botplate_diff_p[12] dac_drive_botplate_diff_p[11] dac_drive_botplate_diff_p[10] dac_drive_botplate_diff_p[9] dac_drive_botplate_diff_p[8] dac_drive_botplate_diff_p[7] dac_drive_botplate_diff_p[6] dac_drive_botplate_diff_p[5] dac_drive_botplate_diff_p[4] dac_drive_botplate_diff_p[3] dac_drive_botplate_diff_p[2] dac_drive_botplate_diff_p[1] dac_drive_botplate_diff_p[0] / caparray

Xcaparray_n vdac_n vss_a dac_drive_botplate_main_n[15] dac_drive_botplate_main_n[14] dac_drive_botplate_main_n[13] dac_drive_botplate_main_n[12] dac_drive_botplate_main_n[11] dac_drive_botplate_main_n[10] dac_drive_botplate_main_n[9] dac_drive_botplate_main_n[8] dac_drive_botplate_main_n[7] dac_drive_botplate_main_n[6] dac_drive_botplate_main_n[5] dac_drive_botplate_main_n[4] dac_drive_botplate_main_n[3] dac_drive_botplate_main_n[2] dac_drive_botplate_main_n[1] dac_drive_botplate_main_n[0] dac_drive_botplate_diff_n[15] dac_drive_botplate_diff_n[14] dac_drive_botplate_diff_n[13] dac_drive_botplate_diff_n[12] dac_drive_botplate_diff_n[11] dac_drive_botplate_diff_n[10] dac_drive_botplate_diff_n[9] dac_drive_botplate_diff_n[8] dac_drive_botplate_diff_n[7] dac_drive_botplate_diff_n[6] dac_drive_botplate_diff_n[5] dac_drive_botplate_diff_n[4] dac_drive_botplate_diff_n[3] dac_drive_botplate_diff_n[2] dac_drive_botplate_diff_n[1] dac_drive_botplate_diff_n[0] / caparray

* Two sampling switch instances
Xsampswitch_p vin_p vdac_p clk_samp_p clk_samp_p_b vdd_a vss_a / sampswitch

Xsampswitch_n vin_n vdac_n clk_samp_n clk_samp_n_b vdd_a vss_a / sampswitch

* One comparator instance
Xcomp vdac_p vdac_n comp_out_p comp_out_n clk_comp vdd_a vss_a / comp

.ENDS adc

* ========== core.cdl ==========
* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT frida_core seq_init seq_samp seq_comp seq_logic spi_sclk spi_sdi spi_sdo spi_cs_b reset_b comp_out vin_p vin_n vdd_a vss_a vdd_d vss_d vdd_dac vss_dac
*.PININFO seq_init:I seq_samp:I seq_comp:I seq_logic:I spi_sclk:I spi_sdi:I spi_sdo:O spi_cs_b:I reset_b:I comp_out:O vin_p:I vin_n:I vdd_a:B vss_a:B vdd_d:B vss_d:B vdd_dac:B vss_dac:B

Xadc_array[0].adc_inst net2801 net2817 net2831 net2847 adc_comparator_out[0]
+ spi_bits[64] spi_bits[65] spi_bits[66] spi_bits[67]
+ spi_bits[68] spi_bits[69] spi_bits[70] net2475 net2478
+ net2480 net2481 net2484 net2486 net2488 net2490 net2492 net2495
+ net2496 net2498 net2501 net2502 net2505 net2507 net2509 net2510
+ net2511 net2512 net2513 net2514 net2515 net2516 net2518 net2520
+ net2521 net2522 net2523 net2525 net2526 net2528 net2529 net2531
+ net2535 net2537 net2539 net2541 net2543 net2545 net2548 net2550
+ net2551 net2554 net2558 net2559 net2561 net2571 net2573 net2574
+ net2590 net2603 net2615 net2627 net2458 net2470 net2471 net2474
+ net2483 net2504 net2517 net2532 net2555 net2638 vin_p vin_n
+ vdd_a vss_a vdd_d vss_d vdd_dac vss_dac adc
Xadc_array[10].adc_inst net2793 net2809 net2823 net2839
+ adc_comparator_out[10] net2597 net2596 net2595 net2594 net2593
+ net2592 net2589 net2477 net2478 net2479 net2482 net2485 net2487
+ net2489 net2491 net2493 net2494 net2497 net2499 net2500 net2503
+ net2506 net2508 net2509 net2510 net2511 net2512 net2513 net2514
+ net2515 net2516 net2519 net2520 net2521 net2522 net2523 net2524
+ net2527 net2528 net2529 net2530 net2535 net2537 net2539 net2542
+ net2544 net2546 net2547 net2549 net2552 net2553 net2557 net2560
+ net2562 net2572 net2573 net2574 net2591 net2602 net2615 net2627
+ net2458 net2470 net2472 net2474 net2483 net2504 net2517 net2533
+ net2556 net2638 vin_p vin_n vdd_a vss_a vdd_d vss_d vdd_dac
+ vss_dac adc
Xadc_array[11].adc_inst net2792 net2808 net2822 net2838
+ adc_comparator_out[11] net2588 net2587 net2586 net2585 net2584
+ net2583 net2582 net2477 net2478 net2479 net2482 net2485 net2487
+ net2489 net2491 net2493 net2494 net2497 net2499 net2500 net2503
+ net2506 net2508 net2509 net2510 net2511 net2512 net2513 net2514
+ net2515 net2516 net2519 net2520 net2521 net2522 net2523 net2524
+ net2527 net2528 net2529 net2530 net2536 net2538 net2540 net2542
+ net2544 net2546 net2547 net2549 net2552 net2553 net2557 net2560
+ net2562 net2572 net2573 net2574 net2591 net2602 net2615 net2627
+ net2458 net2470 net2472 net2474 net2483 net2504 net2517 net2533
+ net2556 net2638 vin_p vin_n vdd_a vss_a vdd_d vss_d vdd_dac
+ vss_dac adc
Xadc_array[12].adc_inst net2796 net2812 net2826 net2842
+ adc_comparator_out[12] net2579 spi_bits[149] spi_bits[150]
+ spi_bits[151] spi_bits[152] spi_bits[153] spi_bits[154]
+ net2475 net2478 net2480 net2481 net2484 net2486 net2488 net2490
+ net2492 net2495 net2496 net2498 net2501 net2502 net2505 net2507
+ net2509 net2510 net2511 net2512 net2513 net2514 net2515 net2516
+ net2518 net2520 net2521 net2522 net2523 net2525 net2526 net2528
+ net2529 net2531 net2535 net2537 net2539 net2541 net2543 net2545
+ net2548 net2550 net2551 net2554 net2558 net2559 net2561 net2571
+ net2573 net2574 net2590 net2603 net2615 net2627 net2458 net2470
+ net2471 net2474 net2483 net2504 net2517 net2532 net2555 net2638
+ vin_p vin_n vdd_a vss_a vdd_d vss_d vdd_dac vss_dac adc
Xadc_array[13].adc_inst net2796 net2812 net2826 net2842
+ adc_comparator_out[13] spi_bits[155] spi_bits[156] spi_bits[157]
+ spi_bits[158] spi_bits[159] spi_bits[160] spi_bits[161]
+ net2477 net2478 net2480 net2481 net2484 net2486 net2488 net2490
+ net2492 net2495 net2496 net2498 net2501 net2502 net2505 net2507
+ net2509 net2510 net2511 net2512 net2513 net2514 net2515 net2516
+ net2518 net2520 net2521 net2522 net2523 net2525 net2526 net2528
+ net2529 net2531 net2535 net2537 net2539 net2541 net2543 net2545
+ net2548 net2550 net2551 net2554 net2558 net2559 net2561 net2571
+ net2573 net2574 net2590 net2603 net2615 net2627 net2458 net2470
+ net2471 net2474 net2483 net2504 net2517 net2532 net2555 net2638
+ vin_p vin_n vdd_a vss_a vdd_d vss_d vdd_dac vss_dac adc
Xadc_array[14].adc_inst net2794 net2810 net2824 net2840
+ adc_comparator_out[14] spi_bits[162] spi_bits[163] spi_bits[164]
+ spi_bits[165] spi_bits[166] spi_bits[167] spi_bits[168]
+ net2477 net2478 net2479 net2482 net2485 net2487 net2489 net2491
+ net2493 net2494 net2497 net2499 net2500 net2503 net2506 net2508
+ net2509 net2510 net2511 net2512 net2513 net2514 net2515 net2516
+ net2519 net2520 net2521 net2522 net2523 net2524 net2527 net2528
+ net2529 net2530 net2535 net2537 net2539 net2542 net2544 net2546
+ net2547 net2549 net2552 net2553 net2557 net2560 net2562 net2572
+ net2573 net2574 net2591 net2602 net2615 net2627 net2458 net2470
+ net2472 net2474 net2483 net2504 net2517 net2533 net2556 net2638
+ vin_p vin_n vdd_a vss_a vdd_d vss_d vdd_dac vss_dac adc
Xadc_array[15].adc_inst net2792 net2808 net2822 net2838
+ adc_comparator_out[15] spi_bits[169] spi_bits[170] spi_bits[171]
+ spi_bits[172] spi_bits[173] spi_bits[174] spi_bits[175]
+ net2477 net2478 net2479 net2482 net2485 net2487 net2489 net2491
+ net2493 net2494 net2497 net2499 net2500 net2503 net2506 net2508
+ net2509 net2510 net2511 net2512 net2513 net2514 net2515 net2516
+ net2519 net2520 net2521 net2522 net2523 net2524 net2527 net2528
+ net2529 net2530 net2536 net2538 net2540 net2542 net2544 net2546
+ net2547 net2549 net2552 net2553 net2557 net2560 net2562 net2572
+ net2573 net2574 net2591 net2602 net2615 net2627 net2458 net2470
+ net2472 net2474 net2483 net2504 net2517 net2533 net2556 net2638
+ vin_p vin_n vdd_a vss_a vdd_d vss_d vdd_dac vss_dac adc
Xadc_array[1].adc_inst net2801 net2817 net2831 net2847 adc_comparator_out[1]
+ net2473 spi_bits[72] spi_bits[73] spi_bits[74] spi_bits[75]
+ spi_bits[76] spi_bits[77] net2477 net2478 net2480 net2481
+ net2484 net2486 net2488 net2490 net2492 net2495 net2496 net2498
+ net2501 net2502 net2505 net2507 net2509 net2510 net2511 net2512
+ net2513 net2514 net2515 net2516 net2518 net2520 net2521 net2522
+ net2523 net2525 net2526 net2528 net2529 net2531 net2535 net2537
+ net2539 net2541 net2543 net2545 net2548 net2550 net2551 net2554
+ net2558 net2559 net2561 net2571 net2573 net2574 net2590 net2603
+ net2615 net2627 net2458 net2470 net2471 net2474 net2483 net2504
+ net2517 net2532 net2555 net2641 vin_p vin_n vdd_a vss_a vdd_d
+ vss_d vdd_dac vss_dac adc
Xadc_array[2].adc_inst net2800 net2816 net2830 net2846 adc_comparator_out[2]
+ spi_bits[78] spi_bits[79] spi_bits[80] spi_bits[81]
+ spi_bits[82] spi_bits[83] spi_bits[84] net2477 net2478
+ net2479 net2482 net2485 net2487 net2489 net2491 net2493 net2494
+ net2497 net2499 net2500 net2503 net2506 net2508 net2509 net2510
+ net2511 net2512 net2513 net2514 net2515 net2516 net2519 net2520
+ net2521 net2522 net2523 net2524 net2527 net2528 net2529 net2530
+ net2535 net2537 net2539 net2542 net2544 net2546 net2547 net2549
+ net2552 net2553 net2557 net2560 net2562 net2572 net2573 net2574
+ net2591 net2602 net2615 net2627 net2458 net2470 net2472 net2474
+ net2483 net2504 net2517 net2533 net2556 net2641 vin_p vin_n
+ vdd_a vss_a vdd_d vss_d vdd_dac vss_dac adc
Xadc_array[3].adc_inst net2798 net2814 net2828 net2844 adc_comparator_out[3]
+ spi_bits[85] spi_bits[86] spi_bits[87] spi_bits[88]
+ spi_bits[89] spi_bits[90] spi_bits[91] net2477 net2478
+ net2479 net2482 net2485 net2487 net2489 net2491 net2493 net2494
+ net2497 net2499 net2500 net2503 net2506 net2508 net2509 net2510
+ net2511 net2512 net2513 net2514 net2515 net2516 net2519 net2520
+ net2521 net2522 net2523 net2524 net2527 net2528 net2529 net2530
+ net2536 net2538 net2540 net2542 net2544 net2546 net2547 net2549
+ net2552 net2553 net2557 net2560 net2562 net2572 net2573 net2574
+ net2591 net2602 net2615 net2627 net2458 net2470 net2472 net2474
+ net2483 net2504 net2517 net2533 net2556 net2641 vin_p vin_n
+ vdd_a vss_a vdd_d vss_d vdd_dac vss_dac adc
Xadc_array[4].adc_inst net2802 net2818 net2832 net2848 adc_comparator_out[4]
+ net2467 net2465 net2464 net2463 net2462 net2461 net2460 net2475
+ net2478 net2480 net2481 net2484 net2486 net2488 net2490 net2492
+ net2495 net2496 net2498 net2501 net2502 net2505 net2507 net2509
+ net2510 net2511 net2512 net2513 net2514 net2515 net2516 net2518
+ net2520 net2521 net2522 net2523 net2525 net2526 net2528 net2529
+ net2531 net2535 net2537 net2539 net2541 net2543 net2545 net2548
+ net2550 net2551 net2554 net2558 net2559 net2561 net2571 net2573
+ net2574 net2590 net2603 net2615 net2627 net2458 net2470 net2471
+ net2474 net2483 net2504 net2517 net2532 net2555 net2638 vin_p
+ vin_n vdd_a vss_a vdd_d vss_d vdd_dac vss_dac adc
Xadc_array[5].adc_inst net2802 net2818 net2832 net2848 adc_comparator_out[5]
+ net2459 net2637 net2636 net2635 net2634 net2633 net2632 net2477
+ net2478 net2480 net2481 net2484 net2486 net2488 net2490 net2492
+ net2495 net2496 net2498 net2501 net2502 net2505 net2507 net2509
+ net2510 net2511 net2512 net2513 net2514 net2515 net2516 net2518
+ net2520 net2521 net2522 net2523 net2525 net2526 net2528 net2529
+ net2531 net2535 net2537 net2539 net2541 net2543 net2545 net2548
+ net2550 net2551 net2554 net2558 net2559 net2561 net2571 net2573
+ net2574 net2590 net2603 net2615 net2627 net2458 net2470 net2471
+ net2474 net2483 net2504 net2517 net2532 net2555 net2638 vin_p
+ vin_n vdd_a vss_a vdd_d vss_d vdd_dac vss_dac adc
Xadc_array[6].adc_inst net2799 net2815 net2829 net2845 adc_comparator_out[6]
+ net2631 net2630 net2629 net2628 net2626 net2625 net2624 net2477
+ net2478 net2479 net2482 net2485 net2487 net2489 net2491 net2493
+ net2494 net2497 net2499 net2500 net2503 net2506 net2508 net2509
+ net2510 net2511 net2512 net2513 net2514 net2515 net2516 net2519
+ net2520 net2521 net2522 net2523 net2524 net2527 net2528 net2529
+ net2530 net2535 net2537 net2539 net2542 net2544 net2546 net2547
+ net2549 net2552 net2553 net2557 net2560 net2562 net2572 net2573
+ net2574 net2591 net2602 net2615 net2627 net2458 net2470 net2472
+ net2474 net2483 net2504 net2517 net2533 net2556 net2638 vin_p
+ vin_n vdd_a vss_a vdd_d vss_d vdd_dac vss_dac adc
Xadc_array[7].adc_inst net2798 net2814 net2828 net2844 adc_comparator_out[7]
+ net2623 net2622 net2621 net2620 net2619 net2618 net2617 net2477
+ net2478 net2479 net2482 net2485 net2487 net2489 net2491 net2493
+ net2494 net2497 net2499 net2500 net2503 net2506 net2508 net2509
+ net2510 net2511 net2512 net2513 net2514 net2515 net2516 net2519
+ net2520 net2521 net2522 net2523 net2524 net2527 net2528 net2529
+ net2530 net2536 net2538 net2540 net2542 net2544 net2546 net2547
+ net2549 net2552 net2553 net2557 net2560 net2562 net2572 net2573
+ net2574 net2591 net2602 net2615 net2627 net2458 net2470 net2472
+ net2474 net2483 net2504 net2517 net2533 net2556 net2638 vin_p
+ vin_n vdd_a vss_a vdd_d vss_d vdd_dac vss_dac adc
Xadc_array[8].adc_inst net2795 net2811 net2825 net2841 adc_comparator_out[8]
+ net2614 net2612 net2611 net2610 net2609 net2608 net2607 net2475
+ net2478 net2480 net2481 net2484 net2486 net2488 net2490 net2492
+ net2495 net2496 net2498 net2501 net2502 net2505 net2507 net2509
+ net2510 net2511 net2512 net2513 net2514 net2515 net2516 net2518
+ net2520 net2521 net2522 net2523 net2525 net2526 net2528 net2529
+ net2531 net2535 net2537 net2539 net2541 net2543 net2545 net2548
+ net2550 net2551 net2554 net2558 net2559 net2561 net2571 net2573
+ net2574 net2590 net2603 net2615 net2627 net2458 net2470 net2471
+ net2474 net2483 net2504 net2517 net2532 net2555 net2638 vin_p
+ vin_n vdd_a vss_a vdd_d vss_d vdd_dac vss_dac adc
Xadc_array[9].adc_inst net2795 net2811 net2825 net2841 adc_comparator_out[9]
+ net2606 net2605 net2604 net2601 net2600 net2599 net2598 net2477
+ net2478 net2480 net2481 net2484 net2486 net2488 net2490 net2492
+ net2495 net2496 net2498 net2501 net2502 net2505 net2507 net2509
+ net2510 net2511 net2512 net2513 net2514 net2515 net2516 net2518
+ net2520 net2521 net2522 net2523 net2525 net2526 net2528 net2529
+ net2531 net2535 net2537 net2539 net2541 net2543 net2545 net2548
+ net2550 net2551 net2554 net2558 net2559 net2561 net2571 net2573
+ net2574 net2590 net2603 net2615 net2627 net2458 net2470 net2471
+ net2474 net2483 net2504 net2517 net2532 net2555 net2638 vin_p
+ vin_n vdd_a vss_a vdd_d vss_d vdd_dac vss_dac adc
Xcomp_mux_43_ net2565 comp_mux_00_ vdd_d vss_d INVD3LVT
Xcomp_mux_44_ net2738 comp_mux_00_ comp_mux_01_ vdd_d vss_d
+ IND2D1LVT
Xinput1 reset_b net1 vdd_d vss_d BUFFD2LVT
Xcomp_mux_46_ net2734 net2565 comp_mux_03_ vdd_d vss_d IND2D1LVT
Xcomp_mux_47_ spi_bits[177] comp_mux_04_ vdd_d vss_d CKND2LVT
Xcomp_mux_48_ comp_mux_01_ comp_mux_03_ comp_mux_04_ comp_mux_05_
+ vdd_d vss_d ND3D1LVT
Xcomp_mux_49_ net2731 comp_mux_00_ comp_mux_06_ vdd_d vss_d
+ IND2D1LVT
Xcomp_mux_50_ net2727 comp_mux_07_ vdd_d vss_d CKND0LVT
Xcomp_mux_51_ net2675 net2563 comp_mux_08_ vdd_d vss_d ND2D1LVT
Xcomp_mux_52_ comp_mux_06_ comp_mux_08_ spi_bits[177]
+ comp_mux_09_ vdd_d vss_d ND3D1LVT
Xcomp_mux_53_ comp_mux_05_ comp_mux_09_ spi_bits[178]
+ comp_mux_10_ vdd_d vss_d ND3D1LVT
Xcomp_mux_54_ comp_mux_00_ net2714 comp_mux_11_ vdd_d vss_d
+ ND2D2LVT
Xcomp_mux_55_ net2565 net2710 comp_mux_12_ vdd_d vss_d ND2D2LVT
Xcomp_mux_56_ comp_mux_11_ comp_mux_12_ comp_mux_13_ vdd_d
+ vss_d ND2D2LVT
Xcomp_mux_57_ comp_mux_13_ comp_mux_04_ comp_mux_14_ vdd_d
+ vss_d ND2D2LVT
Xcomp_mux_58_ net2564 net2744 comp_mux_15_ vdd_d vss_d NR2D2LVT
Xcomp_mux_59_ comp_mux_15_ comp_mux_04_ comp_mux_16_ vdd_d
+ vss_d NR2XD1LVT
Xcomp_mux_60_ net2741 net2563 comp_mux_17_ vdd_d vss_d IND2D1LVT
Xcomp_mux_61_ comp_mux_16_ comp_mux_17_ comp_mux_18_ vdd_d
+ vss_d ND2D2LVT
Xcomp_mux_62_ spi_bits[178] comp_mux_19_ vdd_d vss_d CKND0LVT
Xcomp_mux_63_ comp_mux_14_ comp_mux_18_ comp_mux_19_ comp_mux_20_
+ vdd_d vss_d ND3D1LVT
Xcomp_mux_64_ comp_mux_10_ comp_mux_20_ spi_bits[179]
+ comp_mux_21_ vdd_d vss_d ND3D1LVT
Xcomp_mux_65_ adc_comparator_out[1] net2565 comp_mux_22_
+ vdd_d vss_d IND2D1LVT
Xcomp_mux_66_ adc_comparator_out[0] comp_mux_23_ vdd_d
+ vss_d CKND0LVT
Xcomp_mux_67_ net2674 comp_mux_00_ comp_mux_24_ vdd_d vss_d
+ ND2D1LVT
Xcomp_mux_68_ comp_mux_22_ comp_mux_24_ comp_mux_04_ comp_mux_25_
+ vdd_d vss_d ND3D1LVT
Xcomp_mux_69_ adc_comparator_out[2] comp_mux_26_ vdd_d
+ vss_d CKND0LVT
Xcomp_mux_70_ comp_mux_00_ comp_mux_26_ comp_mux_27_ vdd_d
+ vss_d CKND2D1LVT
Xcomp_mux_71_ adc_comparator_out[3] comp_mux_28_ vdd_d
+ vss_d CKND0LVT
Xcomp_mux_72_ net2673 net2564 comp_mux_29_ vdd_d vss_d CKND2D1LVT
Xcomp_mux_73_ comp_mux_27_ comp_mux_29_ spi_bits[177]
+ comp_mux_30_ vdd_d vss_d ND3D1LVT
Xcomp_mux_74_ comp_mux_25_ comp_mux_30_ comp_mux_19_ comp_mux_31_
+ vdd_d vss_d ND3D1LVT
Xcomp_mux_75_ comp_mux_00_ net2723 comp_mux_32_ vdd_d vss_d
+ ND2D2LVT
Xcomp_mux_76_ net2565 net2720 comp_mux_33_ vdd_d vss_d CKND2D2LVT
Xcomp_mux_77_ comp_mux_32_ comp_mux_33_ comp_mux_34_ vdd_d
+ vss_d ND2D1LVT
Xcomp_mux_78_ comp_mux_34_ comp_mux_04_ comp_mux_35_ vdd_d
+ vss_d CKND2D1LVT
Xcomp_mux_79_ net2564 net2718 comp_mux_36_ vdd_d vss_d NR2D2LVT
Xcomp_mux_80_ comp_mux_36_ comp_mux_04_ comp_mux_37_ vdd_d
+ vss_d NR2XD1LVT
Xcomp_mux_81_ net2874 net2564 comp_mux_38_ vdd_d vss_d IND2D1LVT
Xcomp_mux_82_ comp_mux_37_ comp_mux_38_ comp_mux_39_ vdd_d
+ vss_d ND2D1LVT
Xcomp_mux_83_ comp_mux_35_ comp_mux_39_ spi_bits[178]
+ comp_mux_40_ vdd_d vss_d ND3D2LVT
Xcomp_mux_84_ spi_bits[179] comp_mux_41_ vdd_d vss_d CKND0LVT
Xcomp_mux_85_ comp_mux_31_ comp_mux_40_ comp_mux_41_ comp_mux_42_
+ vdd_d vss_d ND3D2LVT
Xcomp_mux_86_ comp_mux_21_ comp_mux_42_ net4 vdd_d vss_d
+ ND2D1LVT
Xspi_reg_0_ net2 spi_reg_enable vdd_d vss_d CKND3LVT
Xclkbuf_0_seq_init net2790 clknet_0_seq_init vdd_d vss_d BUFFD16LVT
Xspi_reg_sdo_dff_dffe spi_bits[179] net2659 net2789 net2699
+ net5 _unconnected_0 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[0].dff_inst_dffe net3 net2643 clknet_4_6_leaf_spi_sclk
+ net2702 spi_bits[0] _unconnected_1 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[100].dff_inst_dffe spi_bits[99] net2645
+ clknet_4_0_leaf_spi_sclk net2701 spi_bits[100] _unconnected_2
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[101].dff_inst_dffe spi_bits[100]
+ net2645 clknet_4_0_leaf_spi_sclk net2699 spi_bits[101]
+ _unconnected_3 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[102].dff_inst_dffe spi_bits[101]
+ net2659 clknet_4_0_leaf_spi_sclk net2699 spi_bits[102]
+ _unconnected_4 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[103].dff_inst_dffe spi_bits[102]
+ net2659 clknet_4_2_leaf_spi_sclk net2699 spi_bits[103]
+ _unconnected_5 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[104].dff_inst_dffe spi_bits[103]
+ net2659 clknet_4_2_leaf_spi_sclk net2699 spi_bits[104]
+ _unconnected_6 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[105].dff_inst_dffe spi_bits[104]
+ net2659 clknet_4_2_leaf_spi_sclk net2699 spi_bits[105]
+ _unconnected_7 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[106].dff_inst_dffe spi_bits[105]
+ net2649 clknet_4_9_leaf_spi_sclk net2706 spi_bits[106]
+ _unconnected_8 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[107].dff_inst_dffe spi_bits[106]
+ net2653 clknet_4_10_leaf_spi_sclk net2706 spi_bits[107]
+ _unconnected_9 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[108].dff_inst_dffe spi_bits[107]
+ net2653 clknet_4_10_leaf_spi_sclk net2693 spi_bits[108]
+ _unconnected_10 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[109].dff_inst_dffe spi_bits[108]
+ net2654 clknet_4_10_leaf_spi_sclk net2692 spi_bits[109]
+ _unconnected_11 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[10].dff_inst_dffe spi_bits[9] net2653
+ clknet_4_10_leaf_spi_sclk net2692 spi_bits[10] _unconnected_12
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[110].dff_inst_dffe spi_bits[109]
+ net2654 clknet_4_10_leaf_spi_sclk net2692 spi_bits[110]
+ _unconnected_13 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[111].dff_inst_dffe spi_bits[110]
+ net2654 clknet_4_10_leaf_spi_sclk net2692 spi_bits[111]
+ _unconnected_14 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[112].dff_inst_dffe spi_bits[111]
+ net2654 clknet_4_10_leaf_spi_sclk net2691 spi_bits[112]
+ _unconnected_15 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[113].dff_inst_dffe spi_bits[112]
+ net2658 clknet_4_14_leaf_spi_sclk net2676 spi_bits[113]
+ _unconnected_16 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[114].dff_inst_dffe spi_bits[113]
+ net2658 clknet_4_14_leaf_spi_sclk net2678 spi_bits[114]
+ _unconnected_17 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[115].dff_inst_dffe spi_bits[114]
+ net2658 clknet_4_14_leaf_spi_sclk net2678 spi_bits[115]
+ _unconnected_18 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[116].dff_inst_dffe spi_bits[115]
+ net2658 clknet_4_14_leaf_spi_sclk net2678 spi_bits[116]
+ _unconnected_19 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[117].dff_inst_dffe spi_bits[116]
+ net2658 clknet_4_14_leaf_spi_sclk net2678 spi_bits[117]
+ _unconnected_20 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[118].dff_inst_dffe spi_bits[117]
+ net2658 clknet_4_14_leaf_spi_sclk net2678 spi_bits[118]
+ _unconnected_21 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[119].dff_inst_dffe spi_bits[118]
+ net2658 clknet_4_14_leaf_spi_sclk net2678 spi_bits[119]
+ _unconnected_22 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[11].dff_inst_dffe spi_bits[10] net2653
+ clknet_4_10_leaf_spi_sclk net2693 spi_bits[11] _unconnected_23
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[120].dff_inst_dffe net2861 net2648
+ clknet_4_8_leaf_spi_sclk net2695 spi_bits[120] _unconnected_24
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[121].dff_inst_dffe net2756 net2642
+ clknet_4_4_leaf_spi_sclk net2703 spi_bits[121] _unconnected_25
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[122].dff_inst_dffe spi_bits[121]
+ spi_reg_enable clknet_4_4_leaf_spi_sclk net2703 spi_bits[122]
+ _unconnected_26 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[123].dff_inst_dffe spi_bits[122]
+ spi_reg_enable clknet_4_4_leaf_spi_sclk net2704 spi_bits[123]
+ _unconnected_27 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[124].dff_inst_dffe spi_bits[123]
+ spi_reg_enable clknet_4_6_leaf_spi_sclk net2704 spi_bits[124]
+ _unconnected_28 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[125].dff_inst_dffe spi_bits[124]
+ spi_reg_enable clknet_4_6_leaf_spi_sclk net2704 spi_bits[125]
+ _unconnected_29 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[126].dff_inst_dffe spi_bits[125]
+ net2660 clknet_4_6_leaf_spi_sclk net2704 spi_bits[126]
+ _unconnected_30 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[127].dff_inst_dffe spi_bits[126]
+ net2643 clknet_4_6_leaf_spi_sclk net2702 spi_bits[127]
+ _unconnected_31 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[128].dff_inst_dffe spi_bits[127]
+ net2644 clknet_4_1_leaf_spi_sclk net2705 spi_bits[128]
+ _unconnected_32 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[129].dff_inst_dffe spi_bits[128]
+ net2644 clknet_4_1_leaf_spi_sclk net2705 spi_bits[129]
+ _unconnected_33 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[12].dff_inst_dffe spi_bits[11] net2653
+ clknet_4_10_leaf_spi_sclk net2706 spi_bits[12] _unconnected_34
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[130].dff_inst_dffe spi_bits[129]
+ net2646 clknet_4_1_leaf_spi_sclk net2705 spi_bits[130]
+ _unconnected_35 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[131].dff_inst_dffe spi_bits[130]
+ net2646 clknet_4_1_leaf_spi_sclk net2705 spi_bits[131]
+ _unconnected_36 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[132].dff_inst_dffe spi_bits[131]
+ net2646 clknet_4_2_leaf_spi_sclk net2697 spi_bits[132]
+ _unconnected_37 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[133].dff_inst_dffe spi_bits[132]
+ net2646 clknet_4_3_leaf_spi_sclk net2697 spi_bits[133]
+ _unconnected_38 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[134].dff_inst_dffe spi_bits[133]
+ net2649 clknet_4_11_leaf_spi_sclk net2707 spi_bits[134]
+ _unconnected_39 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[135].dff_inst_dffe spi_bits[134]
+ net2650 clknet_4_11_leaf_spi_sclk net2707 spi_bits[135]
+ _unconnected_40 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[136].dff_inst_dffe spi_bits[135]
+ net2650 clknet_4_11_leaf_spi_sclk net2707 spi_bits[136]
+ _unconnected_41 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[137].dff_inst_dffe spi_bits[136]
+ net2652 clknet_4_11_leaf_spi_sclk net2691 spi_bits[137]
+ _unconnected_42 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[138].dff_inst_dffe spi_bits[137]
+ net2652 clknet_4_11_leaf_spi_sclk net2691 spi_bits[138]
+ _unconnected_43 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[139].dff_inst_dffe spi_bits[138]
+ net2654 clknet_4_11_leaf_spi_sclk net2691 spi_bits[139]
+ _unconnected_44 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[13].dff_inst_dffe spi_bits[12] net2653
+ clknet_4_10_leaf_spi_sclk net2706 spi_bits[13] _unconnected_45
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[140].dff_inst_dffe spi_bits[139]
+ net2654 clknet_4_13_leaf_spi_sclk net2690 spi_bits[140]
+ _unconnected_46 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[141].dff_inst_dffe spi_bits[140]
+ net2655 clknet_4_13_leaf_spi_sclk net2676 spi_bits[141]
+ _unconnected_47 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[142].dff_inst_dffe spi_bits[141]
+ net2656 clknet_4_12_leaf_spi_sclk net1 spi_bits[142] _unconnected_48
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[143].dff_inst_dffe spi_bits[142]
+ net2656 clknet_4_12_leaf_spi_sclk net1 spi_bits[143] _unconnected_49
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[144].dff_inst_dffe spi_bits[143]
+ net2656 clknet_4_14_leaf_spi_sclk net1 spi_bits[144] _unconnected_50
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[145].dff_inst_dffe spi_bits[144]
+ net2656 clknet_4_15_leaf_spi_sclk net1 spi_bits[145] _unconnected_51
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[146].dff_inst_dffe spi_bits[145]
+ net2656 clknet_4_15_leaf_spi_sclk net1 spi_bits[146] _unconnected_52
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[147].dff_inst_dffe spi_bits[146]
+ net2656 clknet_4_14_leaf_spi_sclk net2676 spi_bits[147]
+ _unconnected_53 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[148].dff_inst_dffe net2581 net2647
+ clknet_4_2_leaf_spi_sclk net2696 spi_bits[148] _unconnected_54
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[149].dff_inst_dffe net2578 net2664
+ clknet_4_4_leaf_spi_sclk net2687 spi_bits[149] _unconnected_55
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[14].dff_inst_dffe spi_bits[13] net2653
+ clknet_4_10_leaf_spi_sclk net2706 spi_bits[14] _unconnected_56
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[150].dff_inst_dffe net2872 net2666
+ clknet_4_4_leaf_spi_sclk net2688 spi_bits[150] _unconnected_57
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[151].dff_inst_dffe net2765 net2666
+ clknet_4_4_leaf_spi_sclk net2688 spi_bits[151] _unconnected_58
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[152].dff_inst_dffe net2764 net2859
+ net2852 net2856 spi_bits[152] _unconnected_59 vdd_d vss_d
+ EDFCND2LVT
Xspi_reg_shift_stage[153].dff_inst_dffe spi_bits[152]
+ net2859 net2852 net2856 spi_bits[153] _unconnected_60 vdd_d
+ vss_d EDFCND2LVT
Xspi_reg_shift_stage[154].dff_inst_dffe spi_bits[153]
+ net2859 net2852 net2856 spi_bits[154] _unconnected_61 vdd_d
+ vss_d EDFCND2LVT
Xspi_reg_shift_stage[155].dff_inst_dffe net2762 net2665
+ clknet_4_4_leaf_spi_sclk net2747 spi_bits[155] _unconnected_62
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[156].dff_inst_dffe net2761 net2665
+ clknet_4_7_leaf_spi_sclk net2747 spi_bits[156] _unconnected_63
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[157].dff_inst_dffe spi_bits[156]
+ net2667 clknet_4_0_leaf_spi_sclk net2686 spi_bits[157]
+ _unconnected_64 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[158].dff_inst_dffe net2760 net2753
+ clknet_4_7_leaf_spi_sclk net2748 spi_bits[158] _unconnected_65
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[159].dff_inst_dffe spi_bits[158]
+ net2858 clknet_4_7_leaf_spi_sclk net2748 spi_bits[159]
+ _unconnected_66 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[15].dff_inst_dffe spi_bits[14] net2653
+ clknet_4_10_leaf_spi_sclk net2706 spi_bits[15] _unconnected_67
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[160].dff_inst_dffe spi_bits[159]
+ net2858 clknet_4_7_leaf_spi_sclk net2748 spi_bits[160]
+ _unconnected_68 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[161].dff_inst_dffe net2867 net2858
+ clknet_4_3_leaf_spi_sclk net2748 spi_bits[161] _unconnected_69
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[162].dff_inst_dffe spi_bits[161]
+ net2668 clknet_4_9_leaf_spi_sclk net2750 spi_bits[162]
+ _unconnected_70 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[163].dff_inst_dffe spi_bits[162]
+ net2668 clknet_4_9_leaf_spi_sclk net2751 spi_bits[163]
+ _unconnected_71 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[164].dff_inst_dffe spi_bits[163]
+ net2669 clknet_4_11_leaf_spi_sclk net2751 spi_bits[164]
+ _unconnected_72 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[165].dff_inst_dffe net2866 net2669
+ clknet_4_12_leaf_spi_sclk net2751 spi_bits[165] _unconnected_73
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[166].dff_inst_dffe spi_bits[165]
+ net2749 clknet_4_10_leaf_spi_sclk net2683 spi_bits[166]
+ _unconnected_74 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[167].dff_inst_dffe spi_bits[166]
+ net2749 clknet_4_13_leaf_spi_sclk net2683 spi_bits[167]
+ _unconnected_75 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[168].dff_inst_dffe spi_bits[167]
+ net2749 clknet_4_13_leaf_spi_sclk net2683 spi_bits[168]
+ _unconnected_76 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[169].dff_inst_dffe spi_bits[168]
+ net2670 clknet_4_14_leaf_spi_sclk net2682 spi_bits[169]
+ _unconnected_77 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[16].dff_inst_dffe spi_bits[15] net2654
+ clknet_4_11_leaf_spi_sclk net2691 spi_bits[16] _unconnected_78
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[170].dff_inst_dffe spi_bits[169]
+ net2670 clknet_4_14_leaf_spi_sclk net2682 spi_bits[170]
+ _unconnected_79 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[171].dff_inst_dffe net2759 net2857
+ clknet_4_15_leaf_spi_sclk net2860 spi_bits[171] _unconnected_80
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[172].dff_inst_dffe spi_bits[171]
+ net2857 clknet_4_15_leaf_spi_sclk net2860 spi_bits[172]
+ _unconnected_81 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[173].dff_inst_dffe spi_bits[172]
+ net2857 clknet_4_15_leaf_spi_sclk net2860 spi_bits[173]
+ _unconnected_82 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[174].dff_inst_dffe net2864 net2671
+ clknet_4_14_leaf_spi_sclk net2689 spi_bits[174] _unconnected_83
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[175].dff_inst_dffe spi_bits[174]
+ net2671 clknet_4_14_leaf_spi_sclk net2682 spi_bits[175]
+ _unconnected_84 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[176].dff_inst_dffe net2570 net2655
+ clknet_4_14_leaf_spi_sclk net2676 spi_bits[176] _unconnected_85
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[177].dff_inst_dffe net2566 net2648
+ clknet_4_8_leaf_spi_sclk net2695 spi_bits[177] _unconnected_86
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[178].dff_inst_dffe spi_bits[177]
+ net2648 clknet_4_8_leaf_spi_sclk net2695 spi_bits[178]
+ _unconnected_87 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[179].dff_inst_dffe spi_bits[178]
+ net2648 clknet_4_8_leaf_spi_sclk net2695 spi_bits[179]
+ _unconnected_88 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[17].dff_inst_dffe spi_bits[16] net2652
+ clknet_4_13_leaf_spi_sclk net2693 spi_bits[17] _unconnected_89
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[18].dff_inst_dffe spi_bits[17] net2651
+ clknet_4_9_leaf_spi_sclk net2693 spi_bits[18] _unconnected_90
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[19].dff_inst_dffe spi_bits[18] net2651
+ clknet_4_9_leaf_spi_sclk net2694 spi_bits[19] _unconnected_91
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[1].dff_inst_dffe net2640 net2649 clknet_4_8_leaf_spi_sclk
+ net2695 spi_bits[1] _unconnected_92 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[20].dff_inst_dffe spi_bits[19] net2651
+ clknet_4_9_leaf_spi_sclk net2694 spi_bits[20] _unconnected_93
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[21].dff_inst_dffe spi_bits[20] net2651
+ clknet_4_11_leaf_spi_sclk net2694 spi_bits[21] _unconnected_94
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[22].dff_inst_dffe spi_bits[21] net2652
+ clknet_4_13_leaf_spi_sclk net2693 spi_bits[22] _unconnected_95
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[23].dff_inst_dffe spi_bits[22] net2651
+ clknet_4_9_leaf_spi_sclk net2694 spi_bits[23] _unconnected_96
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[24].dff_inst_dffe spi_bits[23] net2651
+ clknet_4_9_leaf_spi_sclk net2694 spi_bits[24] _unconnected_97
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[25].dff_inst_dffe spi_bits[24] net2651
+ clknet_4_9_leaf_spi_sclk net2694 spi_bits[25] _unconnected_98
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[26].dff_inst_dffe spi_bits[25] net2652
+ clknet_4_11_leaf_spi_sclk net2693 spi_bits[26] _unconnected_99
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[27].dff_inst_dffe spi_bits[26] net2657
+ clknet_4_12_leaf_spi_sclk net2690 spi_bits[27] _unconnected_100
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[28].dff_inst_dffe spi_bits[27] net2657
+ clknet_4_12_leaf_spi_sclk net2690 spi_bits[28] _unconnected_101
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[29].dff_inst_dffe spi_bits[28] net2657
+ clknet_4_13_leaf_spi_sclk net2690 spi_bits[29] _unconnected_102
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[2].dff_inst_dffe spi_bits[1] net2651
+ clknet_4_9_leaf_spi_sclk net2694 spi_bits[2] _unconnected_103
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[30].dff_inst_dffe spi_bits[29] net2651
+ clknet_4_9_leaf_spi_sclk net2694 spi_bits[30] _unconnected_104
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[31].dff_inst_dffe spi_bits[30] net2649
+ clknet_4_8_leaf_spi_sclk net2694 spi_bits[31] _unconnected_105
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[32].dff_inst_dffe spi_bits[31] net2648
+ clknet_4_9_leaf_spi_sclk net2695 spi_bits[32] _unconnected_106
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[33].dff_inst_dffe spi_bits[32] net2648
+ clknet_4_8_leaf_spi_sclk net2695 spi_bits[33] _unconnected_107
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[34].dff_inst_dffe spi_bits[33] net2647
+ clknet_4_2_leaf_spi_sclk net2698 spi_bits[34] _unconnected_108
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[35].dff_inst_dffe spi_bits[34] net2659
+ clknet_4_1_leaf_spi_sclk net2699 spi_bits[35] _unconnected_109
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[36].dff_inst_dffe spi_bits[35] net2645
+ clknet_4_0_leaf_spi_sclk net2700 spi_bits[36] _unconnected_110
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[37].dff_inst_dffe spi_bits[36] net2645
+ clknet_4_0_leaf_spi_sclk net2701 spi_bits[37] _unconnected_111
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[38].dff_inst_dffe spi_bits[37] net2659
+ clknet_4_0_leaf_spi_sclk net2699 spi_bits[38] _unconnected_112
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[39].dff_inst_dffe spi_bits[38] net2647
+ clknet_4_2_leaf_spi_sclk net2696 spi_bits[39] _unconnected_113
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[3].dff_inst_dffe spi_bits[2] net2652
+ clknet_4_13_leaf_spi_sclk net2693 spi_bits[3] _unconnected_114
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[40].dff_inst_dffe spi_bits[39] net2659
+ clknet_4_1_leaf_spi_sclk net2699 spi_bits[40] _unconnected_115
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[41].dff_inst_dffe spi_bits[40] net2645
+ clknet_4_0_leaf_spi_sclk net2701 spi_bits[41] _unconnected_116
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[42].dff_inst_dffe spi_bits[41] net2645
+ clknet_4_0_leaf_spi_sclk net2701 spi_bits[42] _unconnected_117
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[43].dff_inst_dffe spi_bits[42] net2647
+ clknet_4_2_leaf_spi_sclk net2698 spi_bits[43] _unconnected_118
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[44].dff_inst_dffe spi_bits[43] net2659
+ clknet_4_2_leaf_spi_sclk net2698 spi_bits[44] _unconnected_119
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[45].dff_inst_dffe spi_bits[44] net2659
+ clknet_4_2_leaf_spi_sclk net2698 spi_bits[45] _unconnected_120
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[46].dff_inst_dffe spi_bits[45] net2659
+ clknet_4_2_leaf_spi_sclk net2698 spi_bits[46] _unconnected_121
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[47].dff_inst_dffe spi_bits[46] net2659
+ clknet_4_2_leaf_spi_sclk net2699 spi_bits[47] _unconnected_122
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[48].dff_inst_dffe spi_bits[47] net2647
+ clknet_4_2_leaf_spi_sclk net2698 spi_bits[48] _unconnected_123
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[49].dff_inst_dffe spi_bits[48] net2647
+ clknet_4_2_leaf_spi_sclk net2697 spi_bits[49] _unconnected_124
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[4].dff_inst_dffe spi_bits[3] net2654
+ clknet_4_13_leaf_spi_sclk net2690 spi_bits[4] _unconnected_125
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[50].dff_inst_dffe spi_bits[49] net2648
+ clknet_4_8_leaf_spi_sclk net2696 spi_bits[50] _unconnected_126
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[51].dff_inst_dffe spi_bits[50] net2646
+ clknet_4_1_leaf_spi_sclk net2700 spi_bits[51] _unconnected_127
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[52].dff_inst_dffe spi_bits[51] net2647
+ clknet_4_3_leaf_spi_sclk net2698 spi_bits[52] _unconnected_128
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[53].dff_inst_dffe spi_bits[52] net2647
+ clknet_4_2_leaf_spi_sclk net2697 spi_bits[53] _unconnected_129
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[54].dff_inst_dffe spi_bits[53] net2648
+ clknet_4_8_leaf_spi_sclk net2696 spi_bits[54] _unconnected_130
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[55].dff_inst_dffe spi_bits[54] net2659
+ clknet_4_3_leaf_spi_sclk net2699 spi_bits[55] _unconnected_131
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[56].dff_inst_dffe spi_bits[55] net2647
+ clknet_4_3_leaf_spi_sclk net2696 spi_bits[56] _unconnected_132
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[57].dff_inst_dffe spi_bits[56] net2647
+ clknet_4_3_leaf_spi_sclk net2696 spi_bits[57] _unconnected_133
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[58].dff_inst_dffe spi_bits[57] net2647
+ clknet_4_3_leaf_spi_sclk net2696 spi_bits[58] _unconnected_134
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[59].dff_inst_dffe spi_bits[58] net2647
+ clknet_4_3_leaf_spi_sclk net2697 spi_bits[59] _unconnected_135
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[5].dff_inst_dffe spi_bits[4] net2654
+ clknet_4_13_leaf_spi_sclk net2691 spi_bits[5] _unconnected_136
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[60].dff_inst_dffe spi_bits[59] net2647
+ clknet_4_3_leaf_spi_sclk net2698 spi_bits[60] _unconnected_137
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[61].dff_inst_dffe spi_bits[60] net2646
+ clknet_4_1_leaf_spi_sclk net2700 spi_bits[61] _unconnected_138
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[62].dff_inst_dffe spi_bits[61] net2643
+ clknet_4_7_leaf_spi_sclk net2701 spi_bits[62] _unconnected_139
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[63].dff_inst_dffe spi_bits[62] net2643
+ clknet_4_7_leaf_spi_sclk net2702 spi_bits[63] _unconnected_140
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[64].dff_inst_dffe spi_bits[63] net2660
+ clknet_4_4_leaf_spi_sclk net2703 spi_bits[64] _unconnected_141
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[65].dff_inst_dffe spi_bits[64] net2660
+ clknet_4_5_leaf_spi_sclk net2704 spi_bits[65] _unconnected_142
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[66].dff_inst_dffe spi_bits[65] net2660
+ clknet_4_5_leaf_spi_sclk net2704 spi_bits[66] _unconnected_143
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[67].dff_inst_dffe spi_bits[66] net2660
+ clknet_4_5_leaf_spi_sclk net2704 spi_bits[67] _unconnected_144
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[68].dff_inst_dffe spi_bits[67] net2660
+ clknet_4_5_leaf_spi_sclk net2704 spi_bits[68] _unconnected_145
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[69].dff_inst_dffe spi_bits[68] net2660
+ clknet_4_5_leaf_spi_sclk net2704 spi_bits[69] _unconnected_146
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[6].dff_inst_dffe spi_bits[5] net2651
+ clknet_4_9_leaf_spi_sclk net2694 spi_bits[6] _unconnected_147
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[70].dff_inst_dffe spi_bits[69] net2660
+ clknet_4_6_leaf_spi_sclk net2704 spi_bits[70] _unconnected_148
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[71].dff_inst_dffe spi_bits[70] net2643
+ clknet_4_6_leaf_spi_sclk net2702 spi_bits[71] _unconnected_149
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[72].dff_inst_dffe spi_bits[71] net2644
+ clknet_4_1_leaf_spi_sclk net2701 spi_bits[72] _unconnected_150
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[73].dff_inst_dffe spi_bits[72] net2645
+ clknet_4_1_leaf_spi_sclk net2700 spi_bits[73] _unconnected_151
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[74].dff_inst_dffe spi_bits[73] net2645
+ clknet_4_1_leaf_spi_sclk net2700 spi_bits[74] _unconnected_152
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[75].dff_inst_dffe spi_bits[74] net2645
+ clknet_4_1_leaf_spi_sclk net2700 spi_bits[75] _unconnected_153
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[76].dff_inst_dffe spi_bits[75] net2646
+ clknet_4_3_leaf_spi_sclk net2700 spi_bits[76] _unconnected_154
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[77].dff_inst_dffe spi_bits[76] net2646
+ clknet_4_2_leaf_spi_sclk net2700 spi_bits[77] _unconnected_155
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[78].dff_inst_dffe spi_bits[77] net2649
+ clknet_4_9_leaf_spi_sclk net2695 spi_bits[78] _unconnected_156
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[79].dff_inst_dffe spi_bits[78] net2651
+ clknet_4_11_leaf_spi_sclk net2693 spi_bits[79] _unconnected_157
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[7].dff_inst_dffe spi_bits[6] net2653
+ clknet_4_10_leaf_spi_sclk net2706 spi_bits[7] _unconnected_158
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[80].dff_inst_dffe spi_bits[79] net2652
+ clknet_4_11_leaf_spi_sclk net2692 spi_bits[80] _unconnected_159
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[81].dff_inst_dffe spi_bits[80] net2652
+ clknet_4_11_leaf_spi_sclk net2692 spi_bits[81] _unconnected_160
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[82].dff_inst_dffe spi_bits[81] net2652
+ clknet_4_11_leaf_spi_sclk net2692 spi_bits[82] _unconnected_161
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[83].dff_inst_dffe spi_bits[82] net2652
+ clknet_4_11_leaf_spi_sclk net2692 spi_bits[83] _unconnected_162
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[84].dff_inst_dffe spi_bits[83] net2654
+ clknet_4_11_leaf_spi_sclk net2691 spi_bits[84] _unconnected_163
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[85].dff_inst_dffe spi_bits[84] net2657
+ clknet_4_12_leaf_spi_sclk net2677 spi_bits[85] _unconnected_164
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[86].dff_inst_dffe spi_bits[85] net2657
+ clknet_4_12_leaf_spi_sclk net2677 spi_bits[86] _unconnected_165
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[87].dff_inst_dffe spi_bits[86] net2658
+ clknet_4_15_leaf_spi_sclk net2677 spi_bits[87] _unconnected_166
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[88].dff_inst_dffe spi_bits[87] net2658
+ clknet_4_15_leaf_spi_sclk net2678 spi_bits[88] _unconnected_167
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[89].dff_inst_dffe spi_bits[88] net2658
+ clknet_4_15_leaf_spi_sclk net2677 spi_bits[89] _unconnected_168
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[8].dff_inst_dffe spi_bits[7] net2653
+ clknet_4_10_leaf_spi_sclk net2693 spi_bits[8] _unconnected_169
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[90].dff_inst_dffe spi_bits[89] net2658
+ clknet_4_15_leaf_spi_sclk net2677 spi_bits[90] _unconnected_170
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[91].dff_inst_dffe spi_bits[90] net2658
+ clknet_4_15_leaf_spi_sclk net2677 spi_bits[91] _unconnected_171
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[92].dff_inst_dffe net2469 net2648 clknet_4_8_leaf_spi_sclk
+ net2696 spi_bits[92] _unconnected_172 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[93].dff_inst_dffe net2757 net2643 clknet_4_6_leaf_spi_sclk
+ net2702 spi_bits[93] _unconnected_173 vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[94].dff_inst_dffe spi_bits[93] net2660
+ clknet_4_4_leaf_spi_sclk net2703 spi_bits[94] _unconnected_174
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[95].dff_inst_dffe spi_bits[94] net2660
+ clknet_4_4_leaf_spi_sclk net2703 spi_bits[95] _unconnected_175
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[96].dff_inst_dffe spi_bits[95] net2660
+ clknet_4_4_leaf_spi_sclk net2703 spi_bits[96] _unconnected_176
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[97].dff_inst_dffe spi_bits[96] net2660
+ clknet_4_4_leaf_spi_sclk net2703 spi_bits[97] _unconnected_177
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[98].dff_inst_dffe spi_bits[97] net2660
+ clknet_4_4_leaf_spi_sclk net2703 spi_bits[98] _unconnected_178
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[99].dff_inst_dffe spi_bits[98] net2643
+ clknet_4_6_leaf_spi_sclk net2702 spi_bits[99] _unconnected_179
+ vdd_d vss_d EDFCND2LVT
Xspi_reg_shift_stage[9].dff_inst_dffe spi_bits[8] net2654
+ clknet_4_10_leaf_spi_sclk net2692 spi_bits[9] _unconnected_180
+ vdd_d vss_d EDFCND2LVT
Xinput2 spi_cs_b net2 vdd_d vss_d BUFFD2LVT
Xinput3 spi_sdi net3 vdd_d vss_d BUFFD2LVT
Xoutput4 net4 comp_out vdd_d vss_d BUFFD2LVT
Xplace2467 net2757 net2467 vdd_d vss_d CKBD2LVT
Xplace2469 net2468 net2469 vdd_d vss_d CKBD2LVT
Xplace2486 spi_bits[58] net2486 vdd_d vss_d BUFFD6LVT
Xplace2487 spi_bits[58] net2487 vdd_d vss_d BUFFD6LVT
Xplace2488 spi_bits[57] net2488 vdd_d vss_d BUFFD6LVT
Xplace2489 spi_bits[57] net2489 vdd_d vss_d BUFFD6LVT
Xplace2490 spi_bits[56] net2490 vdd_d vss_d BUFFD6LVT
Xplace2491 spi_bits[56] net2491 vdd_d vss_d BUFFD6LVT
Xplace2492 spi_bits[55] net2492 vdd_d vss_d BUFFD6LVT
Xplace2493 spi_bits[55] net2493 vdd_d vss_d BUFFD6LVT
Xplace2494 spi_bits[54] net2494 vdd_d vss_d BUFFD6LVT
Xplace2495 spi_bits[54] net2495 vdd_d vss_d BUFFD6LVT
Xplace2496 spi_bits[53] net2496 vdd_d vss_d BUFFD6LVT
Xplace2497 spi_bits[53] net2497 vdd_d vss_d BUFFD6LVT
Xplace2485 spi_bits[59] net2485 vdd_d vss_d BUFFD6LVT
Xplace2498 spi_bits[52] net2498 vdd_d vss_d BUFFD6LVT
Xplace2499 spi_bits[52] net2499 vdd_d vss_d BUFFD6LVT
Xplace2500 spi_bits[51] net2500 vdd_d vss_d BUFFD6LVT
Xplace2501 spi_bits[51] net2501 vdd_d vss_d BUFFD6LVT
Xplace2502 spi_bits[50] net2502 vdd_d vss_d BUFFD6LVT
Xplace2503 spi_bits[50] net2503 vdd_d vss_d BUFFD6LVT
Xplace2504 spi_bits[4] net2504 vdd_d vss_d CKBD16LVT
Xplace2507 spi_bits[48] net2507 vdd_d vss_d BUFFD6LVT
Xplace2508 spi_bits[48] net2508 vdd_d vss_d BUFFD6LVT
Xplace2505 spi_bits[49] net2505 vdd_d vss_d BUFFD6LVT
Xplace2506 spi_bits[49] net2506 vdd_d vss_d BUFFD6LVT
Xplace2509 spi_bits[47] net2509 vdd_d vss_d CKBD16LVT
Xplace2510 spi_bits[46] net2510 vdd_d vss_d CKBD16LVT
Xplace2511 spi_bits[45] net2511 vdd_d vss_d CKBD16LVT
Xplace2512 spi_bits[44] net2512 vdd_d vss_d CKBD16LVT
Xplace2513 spi_bits[43] net2513 vdd_d vss_d CKBD16LVT
Xplace2514 spi_bits[42] net2514 vdd_d vss_d CKBD16LVT
Xplace2515 spi_bits[41] net2515 vdd_d vss_d CKBD16LVT
Xplace2516 spi_bits[40] net2516 vdd_d vss_d CKBD16LVT
Xplace2517 spi_bits[3] net2517 vdd_d vss_d CKBD16LVT
Xplace2519 spi_bits[39] net2519 vdd_d vss_d BUFFD6LVT
Xplace2518 spi_bits[39] net2518 vdd_d vss_d BUFFD6LVT
Xplace2520 spi_bits[38] net2520 vdd_d vss_d CKBD16LVT
Xplace2521 spi_bits[37] net2521 vdd_d vss_d CKBD16LVT
Xplace2522 spi_bits[36] net2522 vdd_d vss_d CKBD16LVT
Xplace2523 spi_bits[35] net2523 vdd_d vss_d CKBD16LVT
Xplace2524 spi_bits[34] net2524 vdd_d vss_d BUFFD6LVT
Xplace2525 spi_bits[34] net2525 vdd_d vss_d BUFFD6LVT
Xplace2526 spi_bits[33] net2526 vdd_d vss_d BUFFD6LVT
Xplace2527 spi_bits[33] net2527 vdd_d vss_d BUFFD6LVT
Xplace2528 spi_bits[32] net2528 vdd_d vss_d CKBD16LVT
Xplace2529 spi_bits[31] net2529 vdd_d vss_d CKBD16LVT
Xplace2532 spi_bits[2] net2532 vdd_d vss_d BUFFD6LVT
Xplace2533 spi_bits[2] net2533 vdd_d vss_d BUFFD6LVT
Xplace2530 spi_bits[30] net2530 vdd_d vss_d BUFFD6LVT
Xplace2531 spi_bits[30] net2531 vdd_d vss_d BUFFD6LVT
Xplace2534 spi_bits[29] net2534 vdd_d vss_d CKBD2LVT
Xplace2536 net2534 net2536 vdd_d vss_d CKBD2LVT
Xplace2535 net2534 net2535 vdd_d vss_d BUFFD6LVT
Xplace2537 spi_bits[28] net2537 vdd_d vss_d BUFFD6LVT
Xplace2538 spi_bits[28] net2538 vdd_d vss_d CKBD2LVT
Xplace2541 spi_bits[26] net2541 vdd_d vss_d BUFFD6LVT
Xplace2542 spi_bits[26] net2542 vdd_d vss_d BUFFD6LVT
Xplace2544 spi_bits[25] net2544 vdd_d vss_d BUFFD6LVT
Xplace2546 spi_bits[24] net2546 vdd_d vss_d BUFFD6LVT
Xplace2543 spi_bits[25] net2543 vdd_d vss_d BUFFD6LVT
Xplace2545 spi_bits[24] net2545 vdd_d vss_d BUFFD6LVT
Xplace2547 spi_bits[23] net2547 vdd_d vss_d BUFFD6LVT
Xplace2548 spi_bits[23] net2548 vdd_d vss_d BUFFD6LVT
Xplace2549 spi_bits[22] net2549 vdd_d vss_d BUFFD6LVT
Xplace2550 spi_bits[22] net2550 vdd_d vss_d BUFFD6LVT
Xplace2551 spi_bits[21] net2551 vdd_d vss_d BUFFD6LVT
Xplace2552 spi_bits[21] net2552 vdd_d vss_d BUFFD6LVT
Xplace2554 spi_bits[20] net2554 vdd_d vss_d BUFFD6LVT
Xplace2553 spi_bits[20] net2553 vdd_d vss_d BUFFD6LVT
Xplace2555 spi_bits[1] net2555 vdd_d vss_d BUFFD6LVT
Xplace2556 spi_bits[1] net2556 vdd_d vss_d BUFFD6LVT
Xplace2557 spi_bits[19] net2557 vdd_d vss_d BUFFD6LVT
Xplace2558 spi_bits[19] net2558 vdd_d vss_d BUFFD6LVT
Xplace2559 spi_bits[18] net2559 vdd_d vss_d BUFFD6LVT
Xplace2560 spi_bits[18] net2560 vdd_d vss_d BUFFD6LVT
Xplace2561 spi_bits[17] net2561 vdd_d vss_d BUFFD6LVT
Xplace2562 spi_bits[17] net2562 vdd_d vss_d BUFFD6LVT
Xplace2573 spi_bits[15] net2573 vdd_d vss_d CKBD16LVT
Xplace2577 net2576 net2577 vdd_d vss_d BUFFD6LVT
Xplace2578 net2577 net2578 vdd_d vss_d BUFFD6LVT
Xplace2579 net2578 net2579 vdd_d vss_d CKBD2LVT
Xwire2873 net2782 net2873 vdd_d vss_d BUFFD3LVT
Xload_slew2872 spi_bits[149] net2872 vdd_d vss_d CKBD2LVT
Xwire2874 net2716 net2874 vdd_d vss_d CKBD4LVT
Xplace2574 spi_bits[14] net2574 vdd_d vss_d CKBD16LVT
Xwire2854 net2855 net2854 vdd_d vss_d BUFFD4LVT
Xplace2581 net2580 net2581 vdd_d vss_d CKBD2LVT
Xplace2582 spi_bits[147] net2582 vdd_d vss_d CKBD2LVT
Xplace2576 net2575 net2576 vdd_d vss_d BUFFD6LVT
Xwire2882 adc_comparator_out[15] net2882 vdd_d vss_d BUFFD3LVT
Xwire2877 net2788 net2877 vdd_d vss_d CKBD3LVT
Xwire2876 net2777 net2876 vdd_d vss_d CKBD4LVT
Xload_slew2870 spi_bits[151] net2870 vdd_d vss_d CKBD1LVT
Xwire2875 net2787 net2875 vdd_d vss_d CKBD3LVT
Xwire2879 net2770 net2879 vdd_d vss_d BUFFD3LVT
Xwire2878 net2772 net2878 vdd_d vss_d CKBD3LVT
Xwire2881 adc_comparator_out[4] net2881 vdd_d vss_d CKBD4LVT
Xwire2880 net2767 net2880 vdd_d vss_d CKBD3LVT
Xwire2839 net2840 net2839 vdd_d vss_d CKBD3LVT
Xwire2840 clknet_1_1_leaf_seq_logic net2840 vdd_d vss_d CKBD4LVT
Xwire2841 net2843 net2841 vdd_d vss_d BUFFD3LVT
Xwire2850 net2851 net2850 vdd_d vss_d BUFFD6LVT
Xwire2849 clknet_1_0_leaf_seq_logic net2849 vdd_d vss_d CKBD4LVT
Xwire2844 net2845 net2844 vdd_d vss_d CKBD4LVT
Xwire2845 net2846 net2845 vdd_d vss_d CKBD3LVT
Xwire2843 clknet_1_1_leaf_seq_logic net2843 vdd_d vss_d CKBD4LVT
Xwire2842 net2843 net2842 vdd_d vss_d CKBD4LVT
Xwire2847 net2849 net2847 vdd_d vss_d CKBD4LVT
Xwire2846 clknet_1_0_leaf_seq_logic net2846 vdd_d vss_d CKBD4LVT
Xwire2848 net2849 net2848 vdd_d vss_d BUFFD3LVT
Xplace2589 spi_bits[140] net2589 vdd_d vss_d CKBD2LVT
Xwire2821 seq_comp net2821 vdd_d vss_d CKBD6LVT
Xwire2822 net2823 net2822 vdd_d vss_d CKBD4LVT
Xwire2824 clknet_1_1_leaf_seq_comp net2824 vdd_d vss_d CKBD4LVT
Xwire2813 clknet_1_1_leaf_seq_samp net2813 vdd_d vss_d CKBD4LVT
Xwire2823 net2824 net2823 vdd_d vss_d CKBD3LVT
Xwire2838 net2839 net2838 vdd_d vss_d CKBD4LVT
Xwire2812 net2813 net2812 vdd_d vss_d CKBD4LVT
Xwire2816 clknet_1_0_leaf_seq_samp net2816 vdd_d vss_d CKBD4LVT
Xwire2814 net2815 net2814 vdd_d vss_d CKBD4LVT
Xplace2604 spi_bits[129] net2604 vdd_d vss_d CKBD2LVT
Xwire2817 net2819 net2817 vdd_d vss_d CKBD4LVT
Xwire2815 net2816 net2815 vdd_d vss_d CKBD3LVT
Xplace2592 spi_bits[139] net2592 vdd_d vss_d CKBD2LVT
Xwire2794 clknet_1_1_leaf_seq_init net2794 vdd_d vss_d CKBD4LVT
Xclkload0 clknet_4_0_leaf_spi_sclk _unconnected_181 vdd_d
+ vss_d BUFFD4LVT
Xclkload1 clknet_4_3_leaf_spi_sclk _unconnected_182 vdd_d
+ vss_d INVD6LVT
Xplace2617 spi_bits[119] net2617 vdd_d vss_d CKBD2LVT
Xplace2616 spi_bits[119] net2616 vdd_d vss_d CKBD2LVT
Xwire2820 net2821 net2820 vdd_d vss_d BUFFD8LVT
Xclkload4 clknet_4_8_leaf_spi_sclk _unconnected_183 vdd_d
+ vss_d BUFFD8LVT
Xplace2613 spi_bits[120] net2613 vdd_d vss_d BUFFD6LVT
Xclkload3 clknet_4_7_leaf_spi_sclk _unconnected_184 vdd_d
+ vss_d BUFFD4LVT
Xclkload2 clknet_4_5_leaf_spi_sclk _unconnected_185 vdd_d
+ vss_d INVD3LVT
Xwire2818 net2819 net2818 vdd_d vss_d BUFFD3LVT
Xplace2614 net2756 net2614 vdd_d vss_d CKBD2LVT
Xwire2819 clknet_1_0_leaf_seq_samp net2819 vdd_d vss_d CKBD4LVT
Xplace2564 net2862 net2564 vdd_d vss_d CKBD2LVT
Xplace2563 spi_bits[176] net2563 vdd_d vss_d CKBD2LVT
Xplace2566 net2862 net2566 vdd_d vss_d CKBD2LVT
Xplace2565 net2564 net2565 vdd_d vss_d CKBD2LVT
Xplace2568 net2567 net2568 vdd_d vss_d BUFFD6LVT
Xwire2793 net2794 net2793 vdd_d vss_d CKBD3LVT
Xplace2567 net2758 net2567 vdd_d vss_d BUFFD6LVT
Xplace2569 net2568 net2569 vdd_d vss_d BUFFD2LVT
Xplace2570 net2569 net2570 vdd_d vss_d CKBD2LVT
Xwire2792 net2793 net2792 vdd_d vss_d CKBD4LVT
Xplace2571 spi_bits[16] net2571 vdd_d vss_d BUFFD6LVT
Xwire2790 net2791 net2790 vdd_d vss_d BUFFD8LVT
Xclkload5 clknet_4_12_leaf_spi_sclk _unconnected_186 vdd_d
+ vss_d BUFFD4LVT
Xclkload6 clknet_4_15_leaf_spi_sclk _unconnected_187 vdd_d
+ vss_d BUFFD8LVT
Xwire2791 seq_init net2791 vdd_d vss_d CKBD6LVT
Xclkbuf_4_6_f_spi_sclk clknet_3_3_0_spi_sclk clknet_4_6_leaf_spi_sclk
+ vdd_d vss_d BUFFD16LVT
Xplace2667 net2665 net2667 vdd_d vss_d CKBD2LVT
Xplace2666 net2665 net2666 vdd_d vss_d CKBD2LVT
Xplace2628 spi_bits[109] net2628 vdd_d vss_d CKBD2LVT
Xplace2668 net2858 net2668 vdd_d vss_d CKBD2LVT
Xclkbuf_4_13_f_spi_sclk clknet_3_6_0_spi_sclk clknet_4_13_leaf_spi_sclk
+ vdd_d vss_d BUFFD16LVT
Xplace2671 net2670 net2671 vdd_d vss_d CKBD2LVT
Xplace2627 spi_bits[10] net2627 vdd_d vss_d CKBD16LVT
Xplace2670 net2749 net2670 vdd_d vss_d CKBD2LVT
Xplace2669 net2668 net2669 vdd_d vss_d CKBD2LVT
Xplace2625 spi_bits[111] net2625 vdd_d vss_d CKBD2LVT
Xplace2626 spi_bits[110] net2626 vdd_d vss_d CKBD2LVT
Xplace2624 spi_bits[112] net2624 vdd_d vss_d CKBD2LVT
Xplace2635 spi_bits[102] net2635 vdd_d vss_d CKBD2LVT
Xplace2634 spi_bits[103] net2634 vdd_d vss_d CKBD2LVT
Xplace2633 spi_bits[104] net2633 vdd_d vss_d CKBD2LVT
Xclkbuf_4_5_f_spi_sclk clknet_3_2_0_spi_sclk clknet_4_5_leaf_spi_sclk
+ vdd_d vss_d BUFFD16LVT
Xclkbuf_4_3_f_spi_sclk clknet_3_1_0_spi_sclk clknet_4_3_leaf_spi_sclk
+ vdd_d vss_d BUFFD16LVT
Xplace2630 spi_bits[107] net2630 vdd_d vss_d CKBD2LVT
Xplace2629 spi_bits[108] net2629 vdd_d vss_d CKBD2LVT
Xplace2632 spi_bits[105] net2632 vdd_d vss_d CKBD2LVT
Xplace2631 spi_bits[106] net2631 vdd_d vss_d CKBD2LVT
Xclkbuf_4_1_f_spi_sclk clknet_3_0_0_spi_sclk clknet_4_1_leaf_spi_sclk
+ vdd_d vss_d BUFFD16LVT
Xclkbuf_3_7_0_spi_sclk net2854 clknet_3_7_0_spi_sclk vdd_d
+ vss_d BUFFD16LVT
Xclkbuf_4_2_f_spi_sclk clknet_3_1_0_spi_sclk clknet_4_2_leaf_spi_sclk
+ vdd_d vss_d BUFFD16LVT
Xclkbuf_4_0_f_spi_sclk clknet_3_0_0_spi_sclk clknet_4_0_leaf_spi_sclk
+ vdd_d vss_d BUFFD16LVT
Xclkbuf_4_4_f_spi_sclk clknet_3_2_0_spi_sclk clknet_4_4_leaf_spi_sclk
+ vdd_d vss_d BUFFD16LVT
Xplace2484 spi_bits[59] net2484 vdd_d vss_d BUFFD6LVT
Xplace2468 spi_bits[91] net2468 vdd_d vss_d CKBD2LVT
Xplace2674 comp_mux_23_ net2674 vdd_d vss_d BUFFD2LVT
Xplace2642 spi_reg_enable net2642 vdd_d vss_d CKBD2LVT
Xplace2643 net2642 net2643 vdd_d vss_d CKBD2LVT
Xplace2638 spi_bits[0] net2638 vdd_d vss_d CKBD16LVT
Xplace2644 net2643 net2644 vdd_d vss_d CKBD2LVT
Xplace2708 net2766 net2708 vdd_d vss_d BUFFD6LVT
Xplace2575 spi_bits[148] net2575 vdd_d vss_d BUFFD6LVT
Xplace2580 spi_bits[147] net2580 vdd_d vss_d CKBD2LVT
Xload_slew2871 spi_bits[150] net2871 vdd_d vss_d CKBD1LVT
Xwire2852 clknet_4_5_leaf_spi_sclk net2852 vdd_d vss_d CKBD4LVT
Xplace2709 net2708 net2709 vdd_d vss_d BUFFD2LVT
Xplace2636 spi_bits[101] net2636 vdd_d vss_d CKBD2LVT
Xplace2637 spi_bits[100] net2637 vdd_d vss_d CKBD2LVT
Xload_slew2868 spi_bits[157] net2868 vdd_d vss_d CKBD1LVT
Xload_slew2865 spi_bits[170] net2865 vdd_d vss_d CKBD1LVT
Xwire2855 clknet_0_spi_sclk net2855 vdd_d vss_d CKBD4LVT
Xwire2851 spi_sclk net2851 vdd_d vss_d CKBD4LVT
Xwire2752 net2689 net2752 vdd_d vss_d CKBD4LVT
Xwire2751 net2684 net2751 vdd_d vss_d BUFFD3LVT
Xwire2826 net2827 net2826 vdd_d vss_d CKBD4LVT
Xwire2825 net2827 net2825 vdd_d vss_d BUFFD3LVT
Xwire2748 net2685 net2748 vdd_d vss_d CKBD4LVT
Xwire2756 net2613 net2756 vdd_d vss_d BUFFD4LVT
Xplace2710 net2709 net2710 vdd_d vss_d CKBD2LVT
Xplace2727 net2726 net2727 vdd_d vss_d CKBD2LVT
Xplace2723 net2722 net2723 vdd_d vss_d CKBD2LVT
Xplace2726 net2725 net2726 vdd_d vss_d BUFFD2LVT
Xplace2714 net2713 net2714 vdd_d vss_d CKBD2LVT
Xwire2755 net2666 net2755 vdd_d vss_d BUFFD3LVT
Xwire2749 net2669 net2749 vdd_d vss_d CKBD4LVT
Xload_slew2750 net2751 net2750 vdd_d vss_d CKBD3LVT
Xload_slew2764 net2870 net2764 vdd_d vss_d CKBD1LVT
Xwire2801 net2803 net2801 vdd_d vss_d CKBD4LVT
Xwire2799 net2800 net2799 vdd_d vss_d CKBD3LVT
Xplace2684 net2683 net2684 vdd_d vss_d CKBD2LVT
Xwire2798 net2799 net2798 vdd_d vss_d CKBD4LVT
Xplace2689 net2682 net2689 vdd_d vss_d CKBD2LVT
Xplace2691 net2690 net2691 vdd_d vss_d CKBD2LVT
Xwire2753 net2754 net2753 vdd_d vss_d CKBD6LVT
Xplace2683 net2682 net2683 vdd_d vss_d CKBD2LVT
Xplace2679 net2678 net2679 vdd_d vss_d BUFFD6LVT
Xplace2696 net2695 net2696 vdd_d vss_d CKBD2LVT
Xplace2678 net2677 net2678 vdd_d vss_d CKBD2LVT
Xplace2673 net2672 net2673 vdd_d vss_d CKBD2LVT
Xwire2754 net2667 net2754 vdd_d vss_d CKBD3LVT
Xplace2672 comp_mux_28_ net2672 vdd_d vss_d CKBD2LVT
Xwire2796 net2797 net2796 vdd_d vss_d CKBD4LVT
Xwire2795 net2797 net2795 vdd_d vss_d BUFFD3LVT
Xclkbuf_4_9_f_spi_sclk clknet_3_4_0_spi_sclk clknet_4_9_leaf_spi_sclk
+ vdd_d vss_d BUFFD16LVT
Xclkbuf_4_8_f_spi_sclk clknet_3_4_0_spi_sclk clknet_4_8_leaf_spi_sclk
+ vdd_d vss_d BUFFD16LVT
Xclkbuf_4_15_f_spi_sclk clknet_3_7_0_spi_sclk clknet_4_15_leaf_spi_sclk
+ vdd_d vss_d BUFFD16LVT
Xplace2618 spi_bits[118] net2618 vdd_d vss_d CKBD2LVT
Xplace2693 net2692 net2693 vdd_d vss_d CKBD2LVT
Xclkbuf_4_7_f_spi_sclk clknet_3_3_0_spi_sclk clknet_4_7_leaf_spi_sclk
+ vdd_d vss_d BUFFD16LVT
Xplace2682 net2681 net2682 vdd_d vss_d CKBD2LVT
Xplace2680 net2679 net2680 vdd_d vss_d BUFFD6LVT
Xplace2681 net2680 net2681 vdd_d vss_d BUFFD2LVT
Xplace2692 net2691 net2692 vdd_d vss_d CKBD2LVT
Xplace2690 net2677 net2690 vdd_d vss_d CKBD2LVT
Xplace2687 net2747 net2687 vdd_d vss_d CKBD2LVT
Xplace2688 net2687 net2688 vdd_d vss_d CKBD2LVT
Xplace2685 net2750 net2685 vdd_d vss_d CKBD2LVT
Xplace2686 net2685 net2686 vdd_d vss_d CKBD2LVT
Xclkbuf_4_12_f_spi_sclk clknet_3_6_0_spi_sclk clknet_4_12_leaf_spi_sclk
+ vdd_d vss_d BUFFD16LVT
Xclkbuf_4_10_f_spi_sclk clknet_3_5_0_spi_sclk clknet_4_10_leaf_spi_sclk
+ vdd_d vss_d BUFFD16LVT
Xclkbuf_4_11_f_spi_sclk clknet_3_5_0_spi_sclk clknet_4_11_leaf_spi_sclk
+ vdd_d vss_d BUFFD16LVT
Xplace2658 net2657 net2658 vdd_d vss_d CKBD2LVT
Xplace2657 net2654 net2657 vdd_d vss_d CKBD2LVT
Xplace2665 net2664 net2665 vdd_d vss_d CKBD2LVT
Xplace2662 net2661 net2662 vdd_d vss_d BUFFD6LVT
Xplace2694 net2693 net2694 vdd_d vss_d CKBD2LVT
Xplace2695 net2694 net2695 vdd_d vss_d CKBD2LVT
Xplace2656 net2655 net2656 vdd_d vss_d CKBD2LVT
Xclkbuf_1_1_f_seq_comp clknet_0_seq_comp clknet_1_1_leaf_seq_comp
+ vdd_d vss_d BUFFD16LVT
Xplace2697 net2696 net2697 vdd_d vss_d CKBD2LVT
Xclkbuf_1_0_f_seq_comp clknet_0_seq_comp clknet_1_0_leaf_seq_comp
+ vdd_d vss_d BUFFD16LVT
Xclkbuf_0_seq_comp net2820 clknet_0_seq_comp vdd_d vss_d BUFFD16LVT
Xplace2707 net2691 net2707 vdd_d vss_d CKBD2LVT
Xclkbuf_1_1_f_seq_samp clknet_0_seq_samp clknet_1_1_leaf_seq_samp
+ vdd_d vss_d BUFFD16LVT
Xplace2706 net2693 net2706 vdd_d vss_d CKBD2LVT
Xclkbuf_3_4_0_spi_sclk net2855 clknet_3_4_0_spi_sclk vdd_d
+ vss_d BUFFD16LVT
Xplace2664 net2663 net2664 vdd_d vss_d CKBD2LVT
Xplace2663 net2662 net2663 vdd_d vss_d BUFFD2LVT
Xplace2661 net2642 net2661 vdd_d vss_d BUFFD6LVT
Xplace2639 spi_bits[0] net2639 vdd_d vss_d CKBD2LVT
Xplace2660 net2642 net2660 vdd_d vss_d CKBD2LVT
Xplace2659 net2645 net2659 vdd_d vss_d CKBD2LVT
Xplace2640 net2639 net2640 vdd_d vss_d CKBD2LVT
Xplace2641 net2640 net2641 vdd_d vss_d CKBD2LVT
Xclkbuf_3_6_0_spi_sclk net2854 clknet_3_6_0_spi_sclk vdd_d
+ vss_d BUFFD16LVT
Xclkbuf_3_5_0_spi_sclk net2854 clknet_3_5_0_spi_sclk vdd_d
+ vss_d BUFFD16LVT
Xplace2698 net2697 net2698 vdd_d vss_d CKBD2LVT
Xclkbuf_3_3_0_spi_sclk net2853 clknet_3_3_0_spi_sclk vdd_d
+ vss_d BUFFD16LVT
Xclkbuf_3_2_0_spi_sclk net2853 clknet_3_2_0_spi_sclk vdd_d
+ vss_d BUFFD16LVT
Xplace2700 net2698 net2700 vdd_d vss_d CKBD2LVT
Xclkbuf_0_spi_sclk net2850 clknet_0_spi_sclk vdd_d vss_d BUFFD16LVT
Xclkbuf_1_1_f_seq_logic clknet_0_seq_logic clknet_1_1_leaf_seq_logic
+ vdd_d vss_d BUFFD16LVT
Xclkbuf_3_1_0_spi_sclk net2855 clknet_3_1_0_spi_sclk vdd_d
+ vss_d BUFFD16LVT
Xclkbuf_3_0_0_spi_sclk net2853 clknet_3_0_0_spi_sclk vdd_d
+ vss_d BUFFD16LVT
Xplace2705 net2697 net2705 vdd_d vss_d CKBD2LVT
Xclkbuf_1_0_f_seq_logic clknet_0_seq_logic clknet_1_0_leaf_seq_logic
+ vdd_d vss_d BUFFD16LVT
Xplace2702 net2701 net2702 vdd_d vss_d CKBD2LVT
Xplace2701 net2700 net2701 vdd_d vss_d CKBD2LVT
Xplace2699 net2698 net2699 vdd_d vss_d CKBD2LVT
Xwire2771 adc_comparator_out[6] net2771 vdd_d vss_d BUFFD4LVT
Xwire2770 adc_comparator_out[7] net2770 vdd_d vss_d CKBD4LVT
Xwire2782 net2783 net2782 vdd_d vss_d CKBD6LVT
Xwire2784 adc_comparator_out[12] net2784 vdd_d vss_d CKBD4LVT
Xclkbuf_1_1_f_seq_init clknet_0_seq_init clknet_1_1_leaf_seq_init
+ vdd_d vss_d BUFFD16LVT
Xwire2769 adc_comparator_out[8] net2769 vdd_d vss_d CKBD4LVT
Xwire2768 net2769 net2768 vdd_d vss_d CKBD6LVT
Xwire2767 adc_comparator_out[9] net2767 vdd_d vss_d CKBD4LVT
Xwire2766 net2880 net2766 vdd_d vss_d CKBD6LVT
Xload_slew2765 net2871 net2765 vdd_d vss_d CKBD1LVT
Xload_slew2763 spi_bits[154] net2763 vdd_d vss_d CKBD4LVT
Xwire2762 net2763 net2762 vdd_d vss_d CKBD4LVT
Xload_slew2761 net2869 net2761 vdd_d vss_d CKBD1LVT
Xplace2713 net2712 net2713 vdd_d vss_d BUFFD2LVT
Xwire2788 adc_comparator_out[10] net2788 vdd_d vss_d CKBD4LVT
Xwire2787 net2877 net2787 vdd_d vss_d CKBD6LVT
Xwire2786 adc_comparator_out[11] net2786 vdd_d vss_d CKBD4LVT
Xplace2677 net2676 net2677 vdd_d vss_d CKBD2LVT
Xplace2675 comp_mux_07_ net2675 vdd_d vss_d CKBD2LVT
Xclkbuf_1_0_f_seq_init clknet_0_seq_init clknet_1_0_leaf_seq_init
+ vdd_d vss_d BUFFD16LVT
Xplace2676 net1 net2676 vdd_d vss_d CKBD2LVT
Xwire2781 adc_comparator_out[13] net2781 vdd_d vss_d CKBD4LVT
Xspi_reg_clk_inv_inv_cell_2789 clknet_4_2_leaf_spi_sclk net2789
+ vdd_d vss_d INVD2LVT
Xwire2783 net2784 net2783 vdd_d vss_d CKBD6LVT
Xwire2785 net2786 net2785 vdd_d vss_d CKBD6LVT
Xwire2772 adc_comparator_out[5] net2772 vdd_d vss_d CKBD4LVT
Xwire2776 net2876 net2776 vdd_d vss_d CKBD6LVT
Xwire2774 net2775 net2774 vdd_d vss_d CKBD6LVT
Xwire2775 net2882 net2775 vdd_d vss_d BUFFD4LVT
Xwire2773 net2774 net2773 vdd_d vss_d CKBD6LVT
Xload_slew2759 net2865 net2759 vdd_d vss_d BUFFD0LVT
Xload_slew2760 net2868 net2760 vdd_d vss_d CKBD1LVT
Xload_slew2758 net2863 net2758 vdd_d vss_d CKBD1LVT
Xwire2757 net2466 net2757 vdd_d vss_d CKBD4LVT
Xclkbuf_0_seq_samp net2804 clknet_0_seq_samp vdd_d vss_d BUFFD16LVT
Xplace2704 net2703 net2704 vdd_d vss_d CKBD2LVT
Xclkbuf_0_seq_logic net2834 clknet_0_seq_logic vdd_d vss_d
+ BUFFD16LVT
Xplace2645 net2644 net2645 vdd_d vss_d CKBD2LVT
Xplace2646 net2645 net2646 vdd_d vss_d CKBD2LVT
Xplace2649 net2648 net2649 vdd_d vss_d CKBD2LVT
Xplace2647 net2646 net2647 vdd_d vss_d CKBD2LVT
Xplace2650 net2649 net2650 vdd_d vss_d CKBD2LVT
Xplace2716 net2715 net2716 vdd_d vss_d CKBD2LVT
Xplace2715 net2879 net2715 vdd_d vss_d BUFFD2LVT
Xclkbuf_1_0_f_seq_samp clknet_0_seq_samp clknet_1_0_leaf_seq_samp
+ vdd_d vss_d BUFFD16LVT
Xplace2703 net2702 net2703 vdd_d vss_d CKBD2LVT
Xplace2652 net2651 net2652 vdd_d vss_d CKBD2LVT
Xplace2648 net2647 net2648 vdd_d vss_d CKBD2LVT
Xplace2651 net2649 net2651 vdd_d vss_d CKBD2LVT
Xplace2653 net2649 net2653 vdd_d vss_d CKBD2LVT
Xplace2655 net2654 net2655 vdd_d vss_d CKBD2LVT
Xplace2654 net2653 net2654 vdd_d vss_d CKBD2LVT
Xplace2615 spi_bits[11] net2615 vdd_d vss_d CKBD16LVT
Xwire2797 clknet_1_1_leaf_seq_init net2797 vdd_d vss_d CKBD4LVT
Xplace2583 spi_bits[146] net2583 vdd_d vss_d CKBD2LVT
Xplace2539 spi_bits[27] net2539 vdd_d vss_d BUFFD6LVT
Xplace2540 spi_bits[27] net2540 vdd_d vss_d CKBD2LVT
Xplace2728 net2776 net2728 vdd_d vss_d BUFFD6LVT
Xplace2732 net2779 net2732 vdd_d vss_d BUFFD6LVT
Xplace2737 net2736 net2737 vdd_d vss_d BUFFD2LVT
Xplace2739 net2785 net2739 vdd_d vss_d BUFFD6LVT
Xplace2742 net2875 net2742 vdd_d vss_d BUFFD6LVT
Xwire1410 net2457 spi_sdo vdd_d vss_d CKBD2LVT
Xplace2457 net5 net2457 vdd_d vss_d BUFFD2LVT
Xplace2458 spi_bits[9] net2458 vdd_d vss_d CKBD16LVT
Xplace2483 spi_bits[5] net2483 vdd_d vss_d CKBD16LVT
Xplace2481 spi_bits[60] net2481 vdd_d vss_d BUFFD6LVT
Xplace2482 spi_bits[60] net2482 vdd_d vss_d BUFFD6LVT
Xplace2479 spi_bits[61] net2479 vdd_d vss_d BUFFD6LVT
Xplace2480 spi_bits[61] net2480 vdd_d vss_d BUFFD6LVT
Xplace2478 spi_bits[62] net2478 vdd_d vss_d CKBD16LVT
Xplace2475 spi_bits[63] net2475 vdd_d vss_d CKBD2LVT
Xplace2477 net2476 net2477 vdd_d vss_d BUFFD6LVT
Xplace2476 spi_bits[63] net2476 vdd_d vss_d CKBD2LVT
Xplace2473 spi_bits[71] net2473 vdd_d vss_d CKBD2LVT
Xplace2474 spi_bits[6] net2474 vdd_d vss_d CKBD16LVT
Xplace2471 spi_bits[7] net2471 vdd_d vss_d BUFFD6LVT
Xplace2472 spi_bits[7] net2472 vdd_d vss_d BUFFD6LVT
Xplace2470 spi_bits[8] net2470 vdd_d vss_d CKBD16LVT
Xplace2466 spi_bits[92] net2466 vdd_d vss_d BUFFD6LVT
Xplace2465 spi_bits[93] net2465 vdd_d vss_d CKBD2LVT
Xplace2461 spi_bits[97] net2461 vdd_d vss_d CKBD2LVT
Xplace2460 spi_bits[98] net2460 vdd_d vss_d CKBD2LVT
Xplace2459 spi_bits[99] net2459 vdd_d vss_d CKBD2LVT
Xplace2462 spi_bits[96] net2462 vdd_d vss_d CKBD2LVT
Xplace2463 spi_bits[95] net2463 vdd_d vss_d CKBD2LVT
Xplace2464 spi_bits[94] net2464 vdd_d vss_d CKBD2LVT
Xplace2572 spi_bits[16] net2572 vdd_d vss_d BUFFD6LVT
Xload_slew2866 spi_bits[164] net2866 vdd_d vss_d CKBD4LVT
Xload_slew2867 spi_bits[160] net2867 vdd_d vss_d CKBD4LVT
Xload_slew2869 spi_bits[155] net2869 vdd_d vss_d CKBD1LVT
Xplace2584 spi_bits[145] net2584 vdd_d vss_d CKBD2LVT
Xload_slew2863 spi_bits[175] net2863 vdd_d vss_d CKBD1LVT
Xload_slew2864 spi_bits[173] net2864 vdd_d vss_d CKBD4LVT
Xplace2585 spi_bits[144] net2585 vdd_d vss_d CKBD2LVT
Xwire2861 net2616 net2861 vdd_d vss_d BUFFD3LVT
Xwire2862 net2563 net2862 vdd_d vss_d CKBD3LVT
Xplace2586 spi_bits[143] net2586 vdd_d vss_d CKBD2LVT
Xwire2859 net2755 net2859 vdd_d vss_d CKBD4LVT
Xwire2860 net2752 net2860 vdd_d vss_d CKBD4LVT
Xplace2587 spi_bits[142] net2587 vdd_d vss_d CKBD2LVT
Xload_slew2858 net2753 net2858 vdd_d vss_d BUFFD4LVT
Xplace2588 spi_bits[141] net2588 vdd_d vss_d CKBD2LVT
Xwire2856 net2745 net2856 vdd_d vss_d BUFFD4LVT
Xwire2857 net2746 net2857 vdd_d vss_d CKBD4LVT
Xplace2590 spi_bits[13] net2590 vdd_d vss_d BUFFD6LVT
Xplace2591 spi_bits[13] net2591 vdd_d vss_d BUFFD6LVT
Xmax_length2853 net2855 net2853 vdd_d vss_d BUFFD4LVT
Xplace2593 spi_bits[138] net2593 vdd_d vss_d CKBD2LVT
Xwire2836 net2837 net2836 vdd_d vss_d CKBD8LVT
Xwire2837 seq_logic net2837 vdd_d vss_d BUFFD4LVT
Xplace2594 spi_bits[137] net2594 vdd_d vss_d CKBD2LVT
Xwire2835 net2836 net2835 vdd_d vss_d BUFFD8LVT
Xplace2595 spi_bits[136] net2595 vdd_d vss_d CKBD2LVT
Xwire2834 net2835 net2834 vdd_d vss_d BUFFD12LVT
Xplace2596 spi_bits[135] net2596 vdd_d vss_d CKBD2LVT
Xwire2833 clknet_1_0_leaf_seq_comp net2833 vdd_d vss_d CKBD4LVT
Xplace2597 spi_bits[134] net2597 vdd_d vss_d CKBD2LVT
Xwire2832 net2833 net2832 vdd_d vss_d BUFFD3LVT
Xplace2598 spi_bits[133] net2598 vdd_d vss_d CKBD2LVT
Xwire2831 net2833 net2831 vdd_d vss_d CKBD4LVT
Xplace2599 spi_bits[132] net2599 vdd_d vss_d CKBD2LVT
Xwire2829 net2830 net2829 vdd_d vss_d CKBD3LVT
Xwire2830 clknet_1_0_leaf_seq_comp net2830 vdd_d vss_d CKBD4LVT
Xplace2600 spi_bits[131] net2600 vdd_d vss_d CKBD2LVT
Xwire2828 net2829 net2828 vdd_d vss_d CKBD4LVT
Xplace2601 spi_bits[130] net2601 vdd_d vss_d CKBD2LVT
Xwire2827 clknet_1_1_leaf_seq_comp net2827 vdd_d vss_d CKBD4LVT
Xplace2602 spi_bits[12] net2602 vdd_d vss_d BUFFD6LVT
Xplace2603 spi_bits[12] net2603 vdd_d vss_d BUFFD6LVT
Xplace2605 spi_bits[128] net2605 vdd_d vss_d CKBD2LVT
Xwire2811 net2813 net2811 vdd_d vss_d BUFFD3LVT
Xplace2606 spi_bits[127] net2606 vdd_d vss_d CKBD2LVT
Xwire2810 clknet_1_1_leaf_seq_samp net2810 vdd_d vss_d CKBD4LVT
Xplace2607 spi_bits[126] net2607 vdd_d vss_d CKBD2LVT
Xwire2808 net2809 net2808 vdd_d vss_d CKBD4LVT
Xwire2809 net2810 net2809 vdd_d vss_d CKBD3LVT
Xplace2608 spi_bits[125] net2608 vdd_d vss_d CKBD2LVT
Xwire2806 net2807 net2806 vdd_d vss_d CKBD8LVT
Xwire2807 seq_samp net2807 vdd_d vss_d BUFFD4LVT
Xplace2609 spi_bits[124] net2609 vdd_d vss_d CKBD2LVT
Xwire2805 net2806 net2805 vdd_d vss_d BUFFD8LVT
Xplace2610 spi_bits[123] net2610 vdd_d vss_d CKBD2LVT
Xwire2804 net2805 net2804 vdd_d vss_d BUFFD12LVT
Xplace2611 spi_bits[122] net2611 vdd_d vss_d CKBD2LVT
Xwire2803 clknet_1_0_leaf_seq_init net2803 vdd_d vss_d CKBD4LVT
Xplace2612 spi_bits[121] net2612 vdd_d vss_d CKBD2LVT
Xwire2802 net2803 net2802 vdd_d vss_d BUFFD3LVT
Xwire2800 clknet_1_0_leaf_seq_init net2800 vdd_d vss_d CKBD4LVT
Xclkbuf_4_14_f_spi_sclk clknet_3_7_0_spi_sclk clknet_4_14_leaf_spi_sclk
+ vdd_d vss_d BUFFD16LVT
Xplace2619 spi_bits[117] net2619 vdd_d vss_d CKBD2LVT
Xplace2620 spi_bits[116] net2620 vdd_d vss_d CKBD2LVT
Xplace2621 spi_bits[115] net2621 vdd_d vss_d CKBD2LVT
Xplace2622 spi_bits[114] net2622 vdd_d vss_d CKBD2LVT
Xplace2623 spi_bits[113] net2623 vdd_d vss_d CKBD2LVT
Xwire2777 net2778 net2777 vdd_d vss_d CKBD6LVT
Xwire2778 adc_comparator_out[14] net2778 vdd_d vss_d BUFFD4LVT
Xwire2779 net2780 net2779 vdd_d vss_d CKBD6LVT
Xwire2780 net2781 net2780 vdd_d vss_d CKBD6LVT
Xplace2735 net2873 net2735 vdd_d vss_d BUFFD6LVT
Xplace2736 net2735 net2736 vdd_d vss_d BUFFD6LVT
Xplace2711 net2768 net2711 vdd_d vss_d BUFFD6LVT
Xplace2712 net2711 net2712 vdd_d vss_d BUFFD6LVT
Xplace2720 net2719 net2720 vdd_d vss_d CKBD2LVT
Xplace2722 net2721 net2722 vdd_d vss_d BUFFD2LVT
Xplace2717 net2771 net2717 vdd_d vss_d BUFFD2LVT
Xplace2718 net2717 net2718 vdd_d vss_d CKBD2LVT
Xplace2719 net2878 net2719 vdd_d vss_d BUFFD2LVT
Xplace2721 net2881 net2721 vdd_d vss_d BUFFD6LVT
Xplace2724 net2773 net2724 vdd_d vss_d BUFFD6LVT
Xplace2725 net2724 net2725 vdd_d vss_d BUFFD6LVT
Xplace2729 net2728 net2729 vdd_d vss_d BUFFD6LVT
Xplace2730 net2729 net2730 vdd_d vss_d BUFFD2LVT
Xplace2731 net2730 net2731 vdd_d vss_d CKBD2LVT
Xplace2733 net2732 net2733 vdd_d vss_d BUFFD2LVT
Xplace2734 net2733 net2734 vdd_d vss_d CKBD2LVT
Xplace2738 net2737 net2738 vdd_d vss_d CKBD2LVT
Xplace2740 net2739 net2740 vdd_d vss_d BUFFD2LVT
Xplace2741 net2740 net2741 vdd_d vss_d CKBD2LVT
Xload_slew2747 net2686 net2747 vdd_d vss_d CKBD3LVT
Xplace2743 net2742 net2743 vdd_d vss_d BUFFD2LVT
Xplace2744 net2743 net2744 vdd_d vss_d CKBD2LVT
Xwire2745 net2688 net2745 vdd_d vss_d BUFFD3LVT
Xwire2746 net2671 net2746 vdd_d vss_d BUFFD3LVT
.ENDS frida_core
