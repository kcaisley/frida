simulator lang=spice
include "PLACEHOLDER_PDK_MODELS"
include "PLACEHOLDER_DUT_NETLIST"
ahdl_include "PLACEHOLDER_TESTBENCH_VA"
tran1 tran stop=35u
saveOptions options save=allpub
options temp=27 scale=1.0
